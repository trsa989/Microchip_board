# IAR project apps_mac_rt_plc_and_go_plus_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CMS16C_0 Atmel ATSAM4CMS16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=ATPL360MB; __SAM4CMS16C_0__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\phy\atpl360\coup_tx_config\coup_params; ..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt; ..\..\..\..\..\..\common\services\ioport; ..\..; ..\..\..\..\..\..\sam\utils; ..\..\..\..\phy\atpl360\coup_tx_config; ..\..\..\..\..\..\common\boards; ..\..\..\..\mac_rt\include; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\common\services\twi; ..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\..\sam\boards\atpl360mb; ..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\sam\drivers\tc; ..; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\components\display\c0216CiZ; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\..\..\sam\utils\cmsis\sam4cm\source\templates; ..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl360_cen_b; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\sam\drivers\twi; ..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\sam\utils\cmsis\sam4cm\include; ..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=ATPL360MB; __SAM4CMS16C_0__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_mac_rt_plc_and_go_plus_flash.bin
  ILINK.IlinkOutputFile: apps_mac_rt_plc_and_go_plus_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\sam\utils\linker_scripts\sam4cm\iar\sam4cms16c_0_flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_G3_MAC_RT_CENB.bin,atpl_bin,P_atpl_bin,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/trng
    ../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/adc
    ../../../../../../sam/drivers/adc/: adc.c adc_sam3u.c adc.h
  group sam/drivers/twi
    ../../../../../../sam/drivers/twi/: twi.c twi.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cm/source/templates
    ../../../../../../sam/utils/cmsis/sam4cm/source/templates/: system_sam4cm.c
  group sam/utils/cmsis/sam4cm/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4cm/source/templates/iar/: startup_sam4cm.c
  group sam/utils/cmsis/sam4cm/include
    ../../../../../../sam/utils/cmsis/sam4cm/include/: sam4cms8c_1.h sam4cmp16c_0.h sam4cms4c_1.h system_sam4cm.h sam4cms8c_0.h sam4cms4c_0.h sam4cm.h sam4cmp8c_0.h sam4cms16c_0.h sam4cmp16c_1.h sam4cmp8c_1.h sam4cms16c_1.h
  group sam/utils/cmsis/sam4cm/include/instance
    ../../../../../../sam/utils/cmsis/sam4cm/include/instance/: tc1.h usart0.h aes.h usart3.h cmcc0.h piob.h adc.h rswdt.h chipid.h matrix1.h rstc.h pmc.h cmcc1.h usart2.h pioa.h pwm.h pioc.h tc0.h ipc0.h rtc.h spi0.h matrix0.h smc1.h ipc1.h icm.h slcdc.h uart0.h wdt.h twi0.h supc.h trng.h spi1.h twi1.h usart1.h uart1.h smc0.h efc.h rtt.h gpbr.h
  group sam/utils/cmsis/sam4cm/include/component
    ../../../../../../sam/utils/cmsis/sam4cm/include/component/: wdt.h pio.h rswdt.h tc.h smc.h pwm.h rtt.h usart.h aes.h trng.h rstc.h pdc.h rtc.h adc.h efc.h chipid.h ipc.h gpbr.h cmcc.h supc.h pmc.h spi.h slcdc.h icm.h uart.h matrix.h twi.h
  group sam/utils/cmsis/sam4cm/include/pio
    ../../../../../../sam/utils/cmsis/sam4cm/include/pio/: sam4cmp16c.h sam4cms8c.h sam4cms16c.h sam4cmp8c.h sam4cms4c.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h stringz.h
  group sam/services/plc/pplc_if/atpl360
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c pplc_if.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/components/display/c0216CiZ
    ../../../../../../sam/components/display/c0216CiZ/: c0216CiZ.c c0216CiZ.h
  group sam/boards/atpl360mb
    ../../../../../../sam/boards/atpl360mb/: init.c atpl360mb.h led.h
  group thirdparty/g3/apps/mac_rt_plc_and_go_plus
    ../../: mac_rt_plc_and_go_plus.c app_plc.c app_console.c app_console.h g3_mac_defs.h app_plc.h
  group thirdparty/g3/apps/mac_rt_plc_and_go_plus/sam4cms16c_atpl360mb_cen_b
    ../: conf_project.h conf_clock.h conf_c0216CiZ.h conf_atpl360.h conf_pplc_if.h conf_board.h conf_uart_serial.h
  group thirdparty/g3/apps/mac_rt_plc_and_go_plus/sam4cms16c_atpl360mb_cen_b/iar
    ./: asf.h
  group thirdparty/g3/phy/atpl360/coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c coup_tx_config.h coup_defs.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_params
    ../../../../phy/atpl360/coup_tx_config/coup_params/: plcoup012_cen_b.h plcoup014_cen_b.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt
    ../../../../phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt/: coup_pl360_wrp.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_conf/pl360_cen_b
    ../../../../phy/atpl360/coup_tx_config/coup_conf/pl360_cen_b/: coup_conf.h
  group thirdparty/g3/mac_rt/include
    ../../../../mac_rt/include/: MacRtConstants.h MacRtDefs.h MacRtMib.h MacRt.h
  group common/components/plc/atpl360_g3_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_boot.c atpl360_hal_spi.c atpl360.c atpl360_hal_spi.h atpl360_exception.h atpl360_boot.h atpl360.h
  group common/components/plc/atpl360_g3_mac_rt/mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c atpl360_comm.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/sam4cm
    ../../../../../../common/services/clock/sam4cm/: sysclk.c genclk.h sysclk.h pll.h osc.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/twi
    ../../../../../../common/services/twi/: twi_slave.h twi_master.h
  group common/services/twi/sam_twi
    ../../../../../../common/services/twi/sam_twi/: twi_slave.h twi_master.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
