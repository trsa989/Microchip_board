# IAR project apps_mac_rt_plc_and_go_plus_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PIC32CX2051MTSH128_0 Microchip PIC32CX2051MTSH128 Core 0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD=PIC32CXMTSH_DB; ARM_MATH_CM4=true; __PIC32CX2051MTSH128_0__
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include; ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\phy\atpl360\coup_tx_config\coup_params; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt; ..\..\..\..\..\..\common\services\ioport; ..\..; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\sam\boards\pic32cxmtsh_db; ..\..\..\..\phy\atpl360\coup_tx_config; ..\..\..\..\..\..\common\boards; ..\..\..\..\mac_rt\include; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\sam\drivers\supc\pic32cx; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates; ..\..\..\..\..\..\sam\components\display\cl010; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\..\..\sam\drivers\pmc\pic32cx; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\..\..\sam\drivers\slcdc; ..\..\..\..\..\..\common\services\serial\pic32cx_uart; ..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt; ..\..\..\..\..\..\sam\drivers\pio\pic32cx; ..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460_fcc_cen_b; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\drivers\usart; ..; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\sam\drivers\rstc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_mac_rt_plc_and_go_plus_flash.bin
  ILINK.IlinkOutputFile: apps_mac_rt_plc_and_go_plus_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\sam\utils\linker_scripts\pic32cx\iar\pic32cx2051mtsh128_0_flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_G3_MAC_RT_CENB.bin,atpl_bin_cenb,P_atpl_bin_cenb,8; --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_G3_MAC_RT_FCC.bin,atpl_bin_fcc,P_atpl_bin_fcc,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  group sam/drivers/trng
    ../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/pmc/pic32cx
    ../../../../../../sam/drivers/pmc/pic32cx/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/slcdc
    ../../../../../../sam/drivers/slcdc/: slcdc.c slcdc.h
  group sam/drivers/rstc
    ../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc/pic32cx
    ../../../../../../sam/drivers/supc/pic32cx/: supc.c supc.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/pio/pic32cx
    ../../../../../../sam/drivers/pio/pic32cx/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/adc
    ../../../../../../sam/drivers/adc/: adc.c adc.h
  group sam/boards/pic32cxmtsh_db
    ../../../../../../sam/boards/pic32cxmtsh_db/: init.c led.h pic32cxmtsh_db.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/pic32cx/source/templates
    ../../../../../../sam/utils/cmsis/pic32cx/source/templates/: system_pic32cx.c
  group sam/utils/cmsis/pic32cx/source/templates/iar
    ../../../../../../sam/utils/cmsis/pic32cx/source/templates/iar/: startup_pic32cx.c
  group sam/utils/cmsis/pic32cx/include
    ../../../../../../sam/utils/cmsis/pic32cx/include/: pic32cx1025mtc100_0.h pic32cx5112mtsh100_1.h pic32cx2051mtc100_0.h pic32cx2051mtg100.h pic32cx2051mtg64.h pic32cx2051mtsh100_1.h system_pic32cx.h pic32cx.h pic32cx1025mtc100_1.h pic32cx5112mtsh100_0.h pic32cx2038mtc100_1.h pic32cx5112mtg100.h pic32cx2051mtc100_1.h pic32cx2051mtsh128_0.h pic32cx2038mtg64.h pic32cx1025mtsh100_0.h pic32cx5112mtsh128_0.h pic32cx2038mtsh100_1.h pic32cx2038mtsh100_0.h pic32cx1025mtg64.h pic32cx5112mtg64.h pic32cx1025mtsh128_1.h pic32cx2038mtg100.h pic32cx5112mtc100_0.h pic32cx2051mtsh128_1.h pic32cx1025mtsh100_1.h pic32cx2038mtc100_0.h pic32cx2038mtsh128_1.h pic32cx1025mtg100.h pic32cx5112mtc100_1.h pic32cx5112mtsh128_1.h pic32cx1025mtsh128_0.h pic32cx2051mtsh100_0.h pic32cx2038mtsh128_0.h
  group sam/utils/cmsis/pic32cx/include/instance
    ../../../../../../sam/utils/cmsis/pic32cx/include/instance/: flexcom4.h usart5.h spi7.h twi2.h twi0.h pmc.h flexcom2.h cmcc0.h ipc1.h matrix2.h twi7.h usart7.h seafec.h rtt.h spi5.h dwdt.h flexcom6.h twi4.h mem2mem0.h matrix0.h spi4.h rstc.h tc0.h trng.h ipc0.h usart0.h usart2.h sha.h sfr.h aes.h sfrbu.h sefc0.h twi6.h spi3.h cpkcc.h flexcom5.h spi1.h gpbr.h pio.h rtc.h tc2.h slcdc.h usart3.h cmcc1.h acc.h qspi.h sefc1.h adc.h i2smcc.h spi2.h matrix3.h syscwp.h twi1.h matrix1.h flexcom0.h twi5.h supc.h tc3.h flexcom1.h tc1.h spi0.h aesb.h flexcom3.h pwm.h icm.h usart6.h usart4.h usart1.h uart.h chipid.h spi6.h twi3.h mcspi.h flexcom7.h mem2mem1.h
  group sam/utils/cmsis/pic32cx/include/component
    ../../../../../../sam/utils/cmsis/pic32cx/include/component/: i2smcc.h mem2mem.h cpkcc.h tc.h twi.h supc.h pmc.h qspi.h rstc.h slcdc.h ipc.h pdc.h emafelpfif.h uart.h trng.h mcspi.h aes.h dwdt.h sfr.h icm.h pwm.h rtt.h pio.h cmcc.h spi.h adc.h sefc.h rtc.h sha.h aesb.h chipid.h sfrbu.h acc.h flexcom.h matrix.h gpbr.h usart.h syscwp.h
  group sam/utils/cmsis/pic32cx/include/pio
    ../../../../../../sam/utils/cmsis/pic32cx/include/pio/: pic32cx5112mtc100.h pic32cx2038mtc100.h pic32cx2051mtsh128.h pic32cx5112mtsh100.h pic32cx2051mtc100.h pic32cx1025mtsh128.h pic32cx2038mtsh100.h pic32cx1025mtsh100.h pic32cx2038mtg64.h pic32cx2051mtsh100.h pic32cx1025mtg100.h pic32cx5112mtg100.h pic32cx2038mtsh128.h pic32cx2051mtg64.h pic32cx5112mtg64.h pic32cx1025mtc100.h pic32cx1025mtg64.h pic32cx2038mtg100.h pic32cx2051mtg100.h pic32cx5112mtsh128.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h mrepeat.h stringz.h tpaste.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/services/plc/pplc_if/atpl360
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c pplc_if.h
  group sam/components/display/cl010
    ../../../../../../sam/components/display/cl010/: cl010_slcdc.c cl010_segmap.h cl010_font.h cl010.h
  group thirdparty/g3/apps/mac_rt_plc_and_go_plus
    ../../: mac_rt_plc_and_go_plus.c app_plc.c app_console.c app_plc.h app_console.h g3_mac_defs.h
  group thirdparty/g3/apps/mac_rt_plc_and_go_plus/pic32cxmtsh_db_pl460_fcc_cen_b
    ../: conf_cl010_slcdc.h conf_sleepmgr.h conf_clock.h conf_atpl360.h conf_slcdc.h conf_pplc_if.h conf_uart_serial.h conf_board.h conf_project.h
  group thirdparty/g3/apps/mac_rt_plc_and_go_plus/pic32cxmtsh_db_pl460_fcc_cen_b/iar
    ./: asf.h
  group thirdparty/g3/phy/atpl360/coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c coup_tx_config.h coup_defs.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_params
    ../../../../phy/atpl360/coup_tx_config/coup_params/: pl460_1_5b_fcc.h pl460_sb_fcc.h pl460_plcoup014_cen_b.h plcoup014_cen_b.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt
    ../../../../phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt/: coup_pl360_wrp.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_conf/pl460_fcc_cen_b
    ../../../../phy/atpl360/coup_tx_config/coup_conf/pl460_fcc_cen_b/: coup_conf.h
  group thirdparty/g3/mac_rt/include
    ../../../../mac_rt/include/: MacRtDefs.h MacRtMib.h MacRt.h MacRtConstants.h
  group common/components/plc/atpl360_g3_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_hal_spi.c atpl360.c atpl360_boot.c atpl360_exception.h atpl360_boot.h atpl360.h atpl360_hal_spi.h
  group common/components/plc/atpl360_g3_mac_rt/mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c atpl360_comm.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/pic32cx_uart
    ../../../../../../common/services/serial/pic32cx_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: pll.h sysclk.h osc.h genclk.h
  group common/services/clock/pic32cx
    ../../../../../../common/services/clock/pic32cx/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/pic32cx
    ../../../../../../common/services/ioport/pic32cx/: ioport_pio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
