# Keil uVision project apps_mac_rt_plc_and_go_plus_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: PIC32CX2051MTSH128:CM4_P0 Microchip
  pack: Microchip.PIC32CX.1.0.0
  cpu: IRAM(0x20000000,0x8C000) IROM(0x01000000,0x200000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: apps_template_app
  c flags: Optim=3 oTime=1 uC99=1 wLevel=2
  c define: BOARD=PIC32CXMTSH_DB ARM_MATH_CM4=true __PIC32CX2051MTSH128_0__
  c misc: --diag_suppress=66
  c include: ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include;..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\phy\atpl360\coup_tx_config\coup_params;..\..\..\..\..\..\sam\utils\fpu;..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt;..\..\..\..\..\..\common\services\ioport;..\..;..\..\..\..\..\..\sam\utils;..\..\..\..\..\..\sam\boards\pic32cxmtsh_db;..\..\..\..\phy\atpl360\coup_tx_config;..\..\..\..\..\..\common\boards;..\..\..\..\mac_rt\include;..\..\..\..\..\..\sam\drivers\pdc;..\..\..\..\..\..\sam\services\flash_efc;..\..\..\..\..\..\sam\boards;..\..\..\..\..\..\sam\drivers\adc;..\..\..\..\..\..\sam\drivers\uart;..\..\..\..\..\..\sam\drivers\supc\pic32cx;..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\common\utils;..\..\..\..\..\..\common\services\delay;..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates;..\..\..\..\..\..\sam\components\display\cl010;..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt;..\..\..\..\..\..\common\services\clock;..\..\..\..\..\..\sam\drivers\flexcom;..\..\..\..\..\..\sam\drivers\pmc\pic32cx;..\..\..\..\..\..\sam\drivers\trng;..\..\..\..\..\..\sam\drivers\slcdc;..\..\..\..\..\..\common\services\serial\pic32cx_uart;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt;..\..\..\..\..\..\sam\drivers\pio\pic32cx;..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460_fcc_cen_b;..\..\..\..\..\..\sam\utils\header_files;..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360;..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\..\sam\drivers\usart;..;..\..\..\..\..\..\common\services\sleepmgr;..\..\..\..\..\..\sam\drivers\rstc;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x1000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x8C000
  scatter file: .\pic32cx2051.sct
  group Startup
    ./: startup_PIC32CX.s retarget.c system_PIC32CX.c atpl_bin_multi.S
  group sam_drivers_trng
    ../../../../../../sam/drivers/trng/: trng.c
  group sam_drivers_pmc_pic32cx
    ../../../../../../sam/drivers/pmc/pic32cx/: sleep.c pmc.c
  group sam_drivers_usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam_drivers_pdc
    ../../../../../../sam/drivers/pdc/: pdc.c
  group sam_drivers_slcdc
    ../../../../../../sam/drivers/slcdc/: slcdc.c
  group sam_drivers_rstc
    ../../../../../../sam/drivers/rstc/: rstc.c
  group sam_drivers_uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam_drivers_efc
    ../../../../../../sam/drivers/efc/: efc.c
  group sam_drivers_supc_pic32cx
    ../../../../../../sam/drivers/supc/pic32cx/: supc.c
  group sam_drivers_tc
    ../../../../../../sam/drivers/tc/: tc.c
  group sam_drivers_flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c
  group sam_drivers_spi
    ../../../../../../sam/drivers/spi/: spi.c
  group sam_drivers_pio_pic32cx
    ../../../../../../sam/drivers/pio/pic32cx/: pio_handler.c pio.c
  group sam_drivers_adc
    ../../../../../../sam/drivers/adc/: adc.c
  group sam_boards_pic32cxmtsh_db
    ../../../../../../sam/boards/pic32cxmtsh_db/: init.c
  group sam_services_flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c
  group sam_services_plc_pplc_if_atpl360
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c
  group sam_components_display_cl010
    ../../../../../../sam/components/display/cl010/: cl010_slcdc.c
  group thirdparty_g3_apps_mac_rt_plc_and_go_plus
    ../../: mac_rt_plc_and_go_plus.c app_plc.c app_console.c
  group thirdparty_g3_phy_atpl360_coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c
  group common_components_plc_atpl360_g3_mac_rt_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c
  group common_components_plc_atpl360_g3_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_hal_spi.c atpl360.c atpl360_boot.c
  group common_services_sleepmgr_sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group common_services_serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common_services_clock_pic32cx
    ../../../../../../common/services/clock/pic32cx/: sysclk.c
  group common_services_delay_sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c
  group common_utils_stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common_utils_interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
