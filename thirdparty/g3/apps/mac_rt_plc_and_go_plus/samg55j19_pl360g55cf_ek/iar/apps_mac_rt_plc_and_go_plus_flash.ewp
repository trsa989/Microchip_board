# IAR project apps_mac_rt_plc_and_go_plus_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=PL360G55CF_EK; __SAMG55J19__; ARM_MATH_CM4=true; UDD_ENABLE
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\phy\atpl360\coup_tx_config\coup_params; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt; ..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\common\services\usb\class\cdc\device; ..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\include; ..\..; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\common\services\usb; ..\..\..\..\phy\atpl360\coup_tx_config; ..\..\..\..\..\..\sam\services\plc\usb_wrp; ..\..\..\..\..\..\common\boards; ..\..\..\..\mac_rt\include; ..\..\..\..\..\..\sam\drivers\wdt; ..\..\..\..\..\..\common\services\usb\udc; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\..\sam\boards\pl360g55cf_ek; ..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl360_cen_a_fcc; ..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\source\templates; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\common\services\usb\class\cdc; ..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\sam\drivers\efc; ..; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\sam\drivers\udp; ..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt; ..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt; ..\..\..\..\..\..\sam\drivers\matrix; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\common\utils\stdio\stdio_udc; ..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_mac_rt_plc_and_go_plus_flash.bin
  ILINK.IlinkOutputFile: apps_mac_rt_plc_and_go_plus_flash.out
  ILINK.IlinkIcfFile: ..\..\..\linker_scripts\iar\samg55_flash_isp.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_G3_MAC_RT_CENA.bin,atpl_bin_cena,P_atpl_bin_cena,8; --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_G3_MAC_RT_FCC.bin,atpl_bin_fcc,P_atpl_bin_fcc,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/g3/apps/mac_rt_plc_and_go_plus
    ../../: mac_rt_plc_and_go_plus.c app_plc.c app_console.c app_plc.h app_console.h g3_mac_defs.h
  group thirdparty/g3/apps/mac_rt_plc_and_go_plus/samg55j19_pl360g55cf_ek
    ../: conf_sleepmgr.h conf_project.h conf_clock.h conf_usb.h conf_pplc_if.h conf_board.h conf_atpl360.h conf_uart_serial.h
  group thirdparty/g3/apps/mac_rt_plc_and_go_plus/samg55j19_pl360g55cf_ek/iar
    ./: asf.h
  group thirdparty/g3/phy/atpl360/coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c coup_tx_config.h coup_defs.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_params
    ../../../../phy/atpl360/coup_tx_config/coup_params/: plcoup011_fcc.h plcoup007_cen_a.h plcoup006_fcc.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_conf/pl360_cen_a_fcc
    ../../../../phy/atpl360/coup_tx_config/coup_conf/pl360_cen_a_fcc/: coup_conf.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt
    ../../../../phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt/: coup_pl360_wrp.h
  group thirdparty/g3/mac_rt/include
    ../../../../mac_rt/include/: MacRtDefs.h MacRtConstants.h MacRtMib.h MacRt.h
  group sam/drivers/udp
    ../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/wdt
    ../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/adc
    ../../../../../../sam/drivers/adc/: adc2.c adc2.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/matrix
    ../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/services/plc/usb_wrp
    ../../../../../../sam/services/plc/usb_wrp/: usb_wrp.c usb_wrp.h
  group sam/services/plc/pplc_if/atpl360
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c pplc_if.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../../sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../../sam/utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../../sam/utils/cmsis/samg/samg55/include/: samg55j18.h samg55g18.h samg55g19.h samg55.h system_samg55.h samg55j19.h samg55n19.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../../sam/utils/cmsis/samg/samg55/include/pio/: samg55g19.h samg55n19.h samg55j19.h samg55g18.h samg55j18.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../../sam/utils/cmsis/samg/samg55/include/instance/: twi5.h pdmic1.h usart2.h pmc.h usart0.h udp.h usart7.h flexcom6.h wdt.h twi7.h uhp.h supc.h usart3.h i2sc0.h piob.h efc.h spi5.h twi6.h flexcom7.h rtt.h flexcom5.h mem2mem.h tc0.h crccu.h twi3.h rstc.h spi7.h twi1.h spi1.h spi3.h usart5.h i2sc1.h chipid.h flexcom0.h spi4.h flexcom3.h flexcom1.h tc1.h flexcom4.h twi2.h spi6.h twi0.h spi0.h pdmic0.h pioa.h spi2.h adc.h rtc.h cmcc.h usart6.h usart1.h usart4.h gpbr.h flexcom2.h matrix.h twi4.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../../sam/utils/cmsis/samg/samg55/include/component/: uhp.h pmc.h supc.h matrix.h cmcc.h flexcom.h rtc.h adc.h rstc.h i2sc.h crccu.h pio.h pdmic.h pdc.h mem2mem.h udp.h gpbr.h efc.h usart.h spi.h rtt.h chipid.h twi.h tc.h wdt.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/boards/pl360g55cf_ek
    ../../../../../../sam/boards/pl360g55cf_ek/: init.c led.h pl360g55cf_ek.h
  group common/services/usb
    ../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/udc
    ../../../../../../common/services/usb/udc/: udc.c udc.h udc_desc.h udd.h udi.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/samg
    ../../../../../../common/services/clock/samg/: sysclk.c sysclk.h osc.h pll.h genclk.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/components/plc/atpl360_g3_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_hal_spi.c atpl360.c atpl360_boot.c atpl360_exception.h atpl360_boot.h atpl360_hal_spi.h atpl360.h
  group common/components/plc/atpl360_g3_mac_rt/mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c atpl360_comm.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_udc
    ../../../../../../common/utils/stdio/stdio_udc/: stdio_udc.h
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../../common/boards/: board.h
