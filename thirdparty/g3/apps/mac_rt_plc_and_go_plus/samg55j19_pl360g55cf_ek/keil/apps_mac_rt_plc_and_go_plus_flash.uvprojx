# Keil uVision project apps_mac_rt_plc_and_go_plus_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAMG55J19 Atmel
  pack: Keil.SAMG_DFP.1.1.0
  cpu: IROM(0x00400000,0x80000) IRAM(0x20000000,0x28000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: apps_template_app
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD=PL360G55CF_EK __SAMG55J19__ ARM_MATH_CM4=true UDD_ENABLE
  c misc: --diag_suppress=66 --gnu
  c include: ..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\phy\atpl360\coup_tx_config\coup_params;..\..\..\..\..\..\sam\utils\fpu;..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt;..\..\..\..\..\..\common\services\ioport;..\..\..\..\..\..\common\services\usb\class\cdc\device;..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\include;..\..;..\..\..\..\..\..\sam\utils;..\..\..\..\..\..\common\services\usb;..\..\..\..\phy\atpl360\coup_tx_config;..\..\..\..\..\..\sam\services\plc\usb_wrp;..\..\..\..\..\..\common\boards;..\..\..\..\mac_rt\include;..\..\..\..\..\..\sam\drivers\wdt;..\..\..\..\..\..\common\services\usb\udc;..\..\..\..\..\..\sam\drivers\pdc;..\..\..\..\..\..\sam\boards;..\..\..\..\..\..\sam\drivers\adc;..\..\..\..\..\..\sam\drivers\pmc;..\..\..\..\..\..\sam\boards\pl360g55cf_ek;..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl360_cen_a_fcc;..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\source\templates;..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\common\utils;..\..\..\..\..\..\common\services\delay;..\..\..\..\..\..\common\services\usb\class\cdc;..\..\..\..\..\..\sam\drivers\pio;..\..\..\..\..\..\sam\drivers\efc;..;..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\..\..\sam\drivers\udp;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt;..\..\..\..\..\..\sam\drivers\supc;..\..\..\..\..\..\common\services\clock;..\..\..\..\..\..\sam\drivers\flexcom;..\..\..\..\..\..\common\services\gpio;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt;..\..\..\..\..\..\sam\drivers\matrix;..\..\..\..\..\..\sam\utils\header_files;..\..\..\..\..\..\common\services\serial\sam_uart;..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360;..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\..\sam\services\flash_efc;..\..\..\..\..\..\common\services\sleepmgr;..\..\..\..\..\..\common\utils\stdio\stdio_udc;..\..\..\..\..\..\sam\drivers\usart;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x400000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\samg55j19.sct
  group Startup
    ./: startup_SAMG55.s retarget.c system_samg55.c atpl_bin_multi.S
  group thirdparty_g3_apps_mac_rt_plc_and_go_plus
    ../../: mac_rt_plc_and_go_plus.c app_plc.c app_console.c
  group thirdparty_g3_phy_atpl360_coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c
  group sam_drivers_udp
    ../../../../../../sam/drivers/udp/: udp_device.c
  group sam_drivers_wdt
    ../../../../../../sam/drivers/wdt/: wdt.c
  group sam_drivers_adc
    ../../../../../../sam/drivers/adc/: adc2.c
  group sam_drivers_usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam_drivers_pdc
    ../../../../../../sam/drivers/pdc/: pdc.c
  group sam_drivers_tc
    ../../../../../../sam/drivers/tc/: tc.c
  group sam_drivers_matrix
    ../../../../../../sam/drivers/matrix/: matrix.c
  group sam_drivers_efc
    ../../../../../../sam/drivers/efc/: efc.c
  group sam_drivers_supc
    ../../../../../../sam/drivers/supc/: supc.c
  group sam_drivers_spi
    ../../../../../../sam/drivers/spi/: spi.c
  group sam_drivers_pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam_drivers_pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam_drivers_flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c
  group sam_services_plc_usb_wrp
    ../../../../../../sam/services/plc/usb_wrp/: usb_wrp.c
  group sam_services_plc_pplc_if_atpl360
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c
  group sam_services_flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c
  group sam_boards_pl360g55cf_ek
    ../../../../../../sam/boards/pl360g55cf_ek/: init.c
  group common_services_usb_class_cdc_device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common_services_usb_udc
    ../../../../../../common/services/usb/udc/: udc.c
  group common_services_clock_samg
    ../../../../../../common/services/clock/samg/: sysclk.c
  group common_services_sleepmgr_sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group common_services_serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common_services_delay_sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c
  group common_components_plc_atpl360_g3_mac_rt_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c
  group common_components_plc_atpl360_g3_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_hal_spi.c atpl360.c atpl360_boot.c
  group common_utils_interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common_utils_stdio
    ../../../../../../common/utils/stdio/: write.c read.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
