# IAR project apps_mac_rt_plc_and_go_plus_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=PL360BN; __SAME70Q21B__; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\phy\atpl360\coup_tx_config\coup_params; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt; ..\..\..\..\..\..\common\services\ioport; ..\..; ..\..\..\..\..\..\sam\utils; ..\..\..\..\phy\atpl360\coup_tx_config; ..\..\..\..\..\..\common\boards; ..\..\..\..\mac_rt\include; ..\..\..\..\..\..\sam\utils\cmsis\same70\include; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\sam\drivers\afec; ..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\sam\drivers\mpu; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt; ..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\trng; ..; ..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl360_cen_b; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\sam\boards\pl360bn; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360; ..\..\..\..\..\..\sam\utils\cmsis\same70\source\templates; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\drivers\xdmac; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=PL360BN; __SAME70Q21B__; ARM_MATH_CM7=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_mac_rt_plc_and_go_plus_flash.bin
  ILINK.IlinkOutputFile: apps_mac_rt_plc_and_go_plus_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\sam\utils\linker_scripts\same70\same70q21\iar\flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_G3_MAC_RT_CENB.bin,atpl_bin,P_atpl_bin,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/mpu
    ../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/xdmac
    ../../../../../../sam/drivers/xdmac/: xdmac.c xdmac.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/afec
    ../../../../../../sam/drivers/afec/: afec.c afec.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/trng
    ../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../sam/utils/cmsis/same70/include/: same70n20b.h same70q21.h same70q19b.h same70j19b.h same70n19.h same70q20b.h same70n20.h same70j20.h same70.h same70n21.h same70q19.h same70q20.h same70j21b.h same70j21.h same70n21b.h same70q21b.h same70j20b.h same70n19b.h same70j19.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../sam/utils/cmsis/same70/include/pio/: same70q20b.h same70n20.h same70q21.h same70j19.h same70j21.h same70n20b.h same70n21.h same70q20.h same70n19.h same70n19b.h same70j20.h same70q19.h same70q19b.h same70j19b.h same70q21b.h same70n21b.h same70j21b.h same70j20b.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../sam/utils/cmsis/same70/include/instance/: qspi.h afec0.h utmi.h dacc.h usart1.h pioc.h i2sc0.h pioe.h rtc.h sdramc.h gmac.h trng.h uart3.h matrix.h tc3.h pioa.h xdmac.h isi.h usart0.h efc.h tc1.h usart2.h twihs1.h usbhs.h tc2.h hsmci.h spi0.h pwm1.h chipid.h twihs2.h uart1.h pwm0.h tc0.h icm.h gpbr.h rtt.h uart4.h aes.h twihs0.h mcan1.h afec1.h spi1.h ssc.h acc.h rswdt.h mcan0.h i2sc1.h piob.h uart2.h supc.h piod.h smc.h rstc.h wdt.h uart0.h pmc.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../sam/utils/cmsis/same70/include/component/: aes.h afec.h mcan.h efc.h gmac.h wdt.h rtc.h xdmac.h uart.h pio.h gpbr.h qspi.h sdramc.h utmi.h usart.h dacc.h pmc.h rstc.h chipid.h matrix.h twihs.h i2sc.h ssc.h usbhs.h rswdt.h supc.h hsmci.h pwm.h smc.h isi.h spi.h icm.h tc.h trng.h rtt.h acc.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h mrepeat.h stringz.h tpaste.h
  group sam/services/plc/pplc_if/atpl360
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c pplc_if.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/boards/pl360bn
    ../../../../../../sam/boards/pl360bn/: init.c pl360bn.h led.h
  group thirdparty/g3/apps/mac_rt_plc_and_go_plus
    ../../: mac_rt_plc_and_go_plus.c app_plc.c app_console.c app_plc.h app_console.h g3_mac_defs.h
  group thirdparty/g3/apps/mac_rt_plc_and_go_plus/same70q21_pl360bn_cen_b
    ../: conf_project.h conf_clock.h conf_uart_serial.h conf_sleepmgr.h conf_pplc_if.h conf_board.h conf_atpl360.h
  group thirdparty/g3/apps/mac_rt_plc_and_go_plus/same70q21_pl360bn_cen_b/iar
    ./: asf.h
  group thirdparty/g3/phy/atpl360/coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c coup_tx_config.h coup_defs.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_params
    ../../../../phy/atpl360/coup_tx_config/coup_params/: plcoup012_cen_b.h plcoup014_cen_b.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt
    ../../../../phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt/: coup_pl360_wrp.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_conf/pl360_cen_b
    ../../../../phy/atpl360/coup_tx_config/coup_conf/pl360_cen_b/: coup_conf.h
  group thirdparty/g3/mac_rt/include
    ../../../../mac_rt/include/: MacRtConstants.h MacRtMib.h MacRtDefs.h MacRt.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/components/plc/atpl360_g3_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_hal_spi.c atpl360.c atpl360_boot.c atpl360_hal_spi.h atpl360_exception.h atpl360_boot.h atpl360.h
  group common/components/plc/atpl360_g3_mac_rt/mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c atpl360_comm.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/same70
    ../../../../../../common/services/clock/same70/: sysclk.c pll.h sysclk.h genclk.h osc.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
