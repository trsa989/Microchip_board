# Keil uVision project apps_dlms_app_coord_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.0
  cpu: IROM(0x00400000,0x00200000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: apps_template_app
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: __G3_STACK__ UDD_ENABLE ARM_MATH_CM7=true __SAME70Q21__ BOARD=ATPL250ABN_V2 __FREERTOS__
  c misc: --diag_suppress=66 --gnu
  c include: ..\..\..\..\routing_wrapper\source;..\..\..\..\..\..\sam\services\plc\usi;..\..\..\..\..\..\common\services\ioport;..\..\..\..\..\..\common\services\usb\class\cdc\device;..\..\..\..\..\freertos\freertos-7.3.0\source\include;..\..\..\..\..\..\common\services\usb;..\..\..\..\..\..\sam\utils\cmsis\same70\include;..\..\..\..\..\cycloneTCP\cyclone_crypto;..\..\..\..\..\..\sam\boards;..\..\..\..\..\..\sam\services\plc\buart_if;..\..\..\..\..\..\sam\drivers\usbhs;..\..\..\..\..\..\sam\drivers\gpbr;..\..\..\..\..\..\common\utils;..\..\..\..\..\..\sam\drivers\pio;..\..\..\..\phy\atpl250\include_multiband;..\..\..\..\..\dlms\client\lib;..\..\..\..\..\mbed-tls\include;..\..\..\..\routing_wrapper\include;..\..\..\..\..\..\sam\utils\cmsis\same70\source\templates;..\..\..\..\coordinator\source;..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\..\sam\services\flash_efc;..\..\..\..\..\..\sam\drivers\xdmac;..\..\..\..\..\cycloneTCP\common;..\..\..\..\..\..\common\utils\stdio\stdio_udc;..\..\..\..\phy\atpl250\addons\sniffer_if;..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\coordinator\include;..\..\..\..\..\..\sam\utils;..\..\..\..\routing_loadng\source;..\..\..\..\mac_rt\include;..\..\..\..\bootstrap_wrapper\source;..\..\..\..\..\..\sam\drivers\aes;..\..\..\..\..\..\sam\drivers\uart;..\..\..\..\..\..\sam\boards\atpl250abn_v2;..\..\..\..\..\cycloneTCP\cyclone_tcp;..\..\..\..\..\..\sam\drivers\mpu;..\..\..\..\oss;..\..\..\..\..\..\sam\drivers\trng;..\..\..\..\bootstrap_wrapper\include;..;..\..\..\..\..\..\sam\utils\header_files;..\..\..\..;..\..\..\..\..\cycloneTCP\module_config;..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\sam\services\plc\busart_if;..\..\..\..\pal\atpl250_g3mac\include;..\..;..\..\..\..\..\..\sam\services\plc\pcrc;..\..\..\..\adp\include;..\..\..;..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f;..\..\..\..\..\..\sam\services\plc\usb_wrp;..\..\..\..\..\..\sam\drivers\wdt;..\..\..\..\..\..\sam\drivers\pmc;..\..\..\..\mac_rt\source;..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\..\..\common\services\gpio;..\..\..\..\..\..\sam\drivers\matrix;..\..\..\..\..\cycloneTCP\atpl_extension;..\..\..\..\bootstrap_lbp\include;..\..\..\..\..\..\common\services\sleepmgr;..\..\..\..\..\..\sam\utils\fpu;..\..\..\..\..\..\common\boards;..\..\..\..\..\dlms\client\profile_g3;..\..\..\..\..\..\common\services\usb\udc;..\..\..\..\..\mbed-tls\sam_aes_alt;..\..\..\..\mac\include;..\..\..\..\..\..\sam\drivers\afec;..\..\..\..\..\..\sam\drivers\sdramc;..\..\..\..\..\..\sam\services\plc\pplc_if\atpl250_multiband;..\..\..\..\routing_loadng\include;..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\common\services\usb\class\cdc;..\..\..\..\bootstrap_lbp\source;..\..\..\..\..\mbed-tls\library;..\..\..\..\common\source;..\..\..\..\..\..\sam\drivers\supc;..\..\..\..\..\..\common\services\clock;..\..\..\..\phy\atpl250\module_config;..\..\..\..\common\include;..\..\..\..\..\..\common\services\serial\sam_uart;..\..\..\..\..\..\sam\drivers\rstc;..\..\..\..\mac_wrapper\include;..\..\..\..\..\..\sam\drivers\usart;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: sram.sct
  link misc: --diag_suppress=L6314
target flash (ARM-ADS)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.0
  cpu: as above
  output: uart
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAME70_XPLD __SAME70Q21__ flash TRACE_LEVEL=4
  c include: ..\..\;..\..\..\..\libraries\libchip;..\..\..\..\libraries\libchip\include;..\..\..\..\libraries\libchip\include\same70;..\..\..\..\libraries\libchip\include\cmsis\CMSIS\Include;..\..\..\..\libraries\libboard;..\..\..\..\libraries\libboard\include
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: flash.sct
  link misc: --diag_suppress=L6314
  group added to the first target's files
    ../../../../../../common/services/clock/same70/: sysclk.c
    ../../../../../../common/services/serial/: usart_serial.c
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
    ../../../../../../common/services/usb/udc/: udc.c
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
    ../../../../../../common/utils/stdio/: read.c write.c
    ../../../../../../sam/boards/atpl250abn_v2/: init.c low_level_init.c
    ../../../../../../sam/drivers/aes/: aes.c
    ../../../../../../sam/drivers/afec/: afec.c
    ../../../../../../sam/drivers/efc/: efc.c
    ../../../../../../sam/drivers/gpbr/: gpbr.c
    ../../../../../../sam/drivers/matrix/: matrix.c
    ../../../../../../sam/drivers/mpu/: mpu.c
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c
    ../../../../../../sam/drivers/rstc/: rstc.c
    ../../../../../../sam/drivers/sdramc/: sdramc.c
    ../../../../../../sam/drivers/spi/: spi.c
    ../../../../../../sam/drivers/supc/: supc.c
    ../../../../../../sam/drivers/tc/: tc.c
    ../../../../../../sam/drivers/trng/: trng.c
    ../../../../../../sam/drivers/uart/: uart.c
    ../../../../../../sam/drivers/usart/: usart.c
    ../../../../../../sam/drivers/usbhs/: usbhs_device.c
    ../../../../../../sam/drivers/wdt/: wdt.c
    ../../../../../../sam/drivers/xdmac/: xdmac.c
    ../../../../../../sam/services/flash_efc/: flash_efc.c
    ../../../../../../sam/services/plc/buart_if/: buart_if.c
    ../../../../../../sam/services/plc/busart_if/: busart_if.c
    ../../../../../../sam/services/plc/pcrc/: pcrc.c
    ../../../../../../sam/services/plc/pplc_if/atpl250_multiband/: pplc_if.c
    ../../../../../../sam/services/plc/usb_wrp/: usb_wrp.c
    ../../../../../../sam/services/plc/usi/: usi.c
    ../../../../../cycloneTCP/atpl_extension/: async_ping.c
    ../../../../../cycloneTCP/common/: cpu_endian.c date_time.c debug.c os_port_none.c path.c str.c
    ../../../../../cycloneTCP/cyclone_crypto/encoding/: asn1.c oid.c
    ../../../../../cycloneTCP/cyclone_tcp/core/: ethernet.c ethernet_misc.c ip.c net.c net_mem.c nic.c ping.c raw_socket.c socket.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c
    ../../../../../cycloneTCP/cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cycloneTCP/cyclone_tcp/dns_sd/: dns_sd.c
    ../../../../../cycloneTCP/cyclone_tcp/drivers/g3/: network_adapter_g3.c
    ../../../../../cycloneTCP/cyclone_tcp/drivers/mac/: same70_eth_driver.c
    ../../../../../cycloneTCP/cyclone_tcp/drivers/phy/: ksz8081_driver.c
    ../../../../../cycloneTCP/cyclone_tcp/drivers/: plc_buart.c
    ../../../../../cycloneTCP/cyclone_tcp/ipv6/: icmpv6.c ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c ipv6_routing.c mld.c ndp.c ndp_cache.c ndp_misc.c ndp_router_adv.c slaac.c
    ../../../../../cycloneTCP/cyclone_tcp/mdns/: mdns_client.c mdns_common.c mdns_responder.c
    ../../../../../cycloneTCP/cyclone_tcp/mibs/: ip_mib_impl.c ip_mib_module.c mib2_impl.c mib2_module.c mib_common.c tcp_mib_impl.c tcp_mib_module.c udp_mib_impl.c udp_mib_module.c
    ../../../../../cycloneTCP/cyclone_tcp/ppp/: chap.c ipcp.c ipv6cp.c lcp.c pap.c ppp.c ppp_debug.c ppp_fsm.c ppp_hdlc.c ppp_misc.c
    ../../../../../dlms/client/profile_g3/: dlms_cli_data_example.c
    ../../../../../dlms/libs/keil/: libsamM4-dlms-client-keil.lib
    ../../../../../mbed-tls/library/: aes_tls.c aesni.c ccm.c cipher.c cipher_wrap.c cmac.c debug_tls.c error.c gcm.c memory_buffer_alloc.c oid_tls.c platform.c platform_util.c timing.c version.c version_features.c
    ../../../../../mbed-tls/sam_aes_alt/: aes_alt.c
    ../../../../adp/: AdpConf.c
    ../../../../bootstrap_lbp/source/: ProcessLbp.c ProtoEapPsk.c ProtoLbp.c
    ../../../../bootstrap_wrapper/source/: BootstrapWrapper.c
    ../../../../common/source/: Byte.c Logger.c QueueMng.c Random.c Timer.c
    ../../../../coordinator/source/: bs_functions.c bs_main.c
    ../../../../crypto/: aes_wrapper.c cipher_wrapper.c eax.c
    ../../../../hal/SAM/: hal.c
    ../../../../libs/keil/: lib-g3-keil-adp.lib lib-g3-keil-loadng.lib lib-g3-keil-mac.lib
    ../../../../mac_rt/source/: MacRt.c MacRtConstants.c MacRtMib.c
    ../../../../mac_wrapper/source/: mac_wrapper.c
    ../../../../oss/: oss_if.c
    ../../../../pal/atpl250_g3mac/source/: pal.c
    ../../../../phy/atpl250/addons/sniffer_if/: sniffer_if.c
    ../../../../phy/atpl250/source_multiband/: atpl250.c atpl250_aux_func_as.S atpl250_ber.c atpl250_carrier_mapping.c atpl250_channel_estimation.c atpl250_channel_estimation_as.S atpl250_demodulator.S atpl250_fch.c atpl250_hw_init.c atpl250_jump_ram.c atpl250_mod_demod.c atpl250_modulator.S atpl250_reed_solomon.c atpl250_sampling_error_estimation.c atpl250_sampling_error_estimation_as.S atpl250_txrx_chain.c
    ../../../../routing_wrapper/source/: RoutingWrapper.c
    ../../../../storage/: storage.c
    ../../: app_adp_mng.c app_dispatcher.c app_dlms_coord.c app_ping_coord.c app_udp_responder.c dlms_cli_data.c ipv6_mng.c main.c
    ./: retarget.c startup_SAME70.s system_same70.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
