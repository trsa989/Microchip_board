# IAR project apps_dlms_app_coord_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __G3_STACK__; __FREERTOS__; BOARD=ATPL250CH; __SAMG55J19__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\routing_wrapper\source; ..\..\..\..\..\..\sam\services\plc\pcrc; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\sam\services\plc\buart_if; ..\..\..\..\mac\include; ..\..\..\..\..\..\common\services\ioport; ..\..\..; ..\..\..\..\coordinator\include; ..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\include; ..\..\..\..\..\cycloneTCP\cyclone_crypto; ..\..\..\..\..\..\sam\utils; ..\..\..\..\routing_loadng\source; ..\..\..\..\routing_wrapper\include; ..\..\..\..\..\..\common\boards; ..\..\..\..\..\dlms\client\profile_g3; ..\..\..\..\bootstrap_wrapper\source; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\adp\include; ..\..\..\..\common\source; ..\..\..\..\..\dlms\client\lib; ..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\cycloneTCP\cyclone_tcp; ..\..\..\..\..\..\sam\services\plc\pplc_if\atpl250_multiband; ..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\source\templates; ..\..\..\..\routing_loadng\include; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\bootstrap_lbp\source; ..\..\..\..\..\mbed-tls\library; ..\..\..\..\phy\atpl250\include_multiband; ..; ..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\phy\atpl250\addons\sniffer_if; ..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\mac_rt\source; ..\..\..\..\oss; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\phy\atpl250\module_config; ..\..\..\..\bootstrap_wrapper\include; ..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f; ..\..\..\..\..\..\sam\services\plc\usi; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\common\include; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..; ..\..\..\..\..\cycloneTCP\module_config; ..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\cycloneTCP\atpl_extension; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\sam\boards\atpl250ch; ..\..\..\..\..\..\sam\services\plc\busart_if; ..\..\..\..\coordinator\source; ..\..\..\..\pal\atpl250_g3mac\include; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\drivers\usart; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\bootstrap_lbp\include; ..\..\..\..\mac_wrapper\include; ..\..\..\..\..\cycloneTCP\common; ..\..\..\..\..\mbed-tls\include; ..\..; ..\..\..\..\mac_rt\include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_dlms_app_coord_flash.bin
  ILINK.IlinkOutputFile: apps_dlms_app_coord_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\sam\utils\linker_scripts\samg\samg55j19\iar\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/g3/libs/iar
    ../../../../libs/iar/: lib-g3-iar-loadng.a lib-g3-iar-mac.a lib-g3-iar-adp.a
  group thirdparty/g3/common/source
    ../../../../common/source/: Logger.c Timer.c Random.c Byte.c QueueMng.c
  group thirdparty/g3/common/include
    ../../../../common/include/: g3_stack_version.h Timer.h Logger.h Random.h Byte.h QueueMng.h
  group thirdparty/g3/crypto
    ../../../../crypto/: aes_wrapper.c cipher_wrapper.c eax.c cipher_wrapper.h brg_types.h brg_endian.h aes_wrapper.h eax.h mode_hdr.h
  group thirdparty/g3/bootstrap_lbp/source
    ../../../../bootstrap_lbp/source/: ProcessLbp.c ProtoEapPsk.c ProtoLbp.c ProtoLbpVersion.h
  group thirdparty/g3/bootstrap_lbp/include
    ../../../../bootstrap_lbp/include/: ProtoLbp.h ProcessLbp.h ProtoEapPsk.h
  group thirdparty/g3/coordinator/source
    ../../../../coordinator/source/: bs_functions.c bs_main.c bs_functions.h
  group thirdparty/g3/coordinator/include
    ../../../../coordinator/include/: bs_api.h
  group thirdparty/g3/hal
    ../../../../hal/: hal.h
  group thirdparty/g3/hal/SAM
    ../../../../hal/SAM/: hal.c hal.h
  group thirdparty/g3/phy/atpl250/addons/sniffer_if
    ../../../../phy/atpl250/addons/sniffer_if/: sniffer_if.c sniffer_if.h
  group thirdparty/g3/phy/atpl250/source_multiband
    ../../../../phy/atpl250/source_multiband/: atpl250_ber.c atpl250_modulator.S atpl250_sampling_error_estimation_as.S atpl250.c atpl250_channel_estimation.c atpl250_reed_solomon.c atpl250_hw_init.c atpl250_jump_ram.c atpl250_fch.c atpl250_txrx_chain.c atpl250_aux_func_as.S atpl250_demodulator.S atpl250_mod_demod.c atpl250_carrier_mapping.c atpl250_sampling_error_estimation.c atpl250_channel_estimation_as.S
  group thirdparty/g3/phy/atpl250/include_multiband
    ../../../../phy/atpl250/include_multiband/: atpl250_hw_init.h atpl250_jump_ram.h atpl250_fch.h atpl250_ber.h atpl250.h atpl250_version.h atpl250_txrx_chain.h atpl250_sampling_error_estimation.h atpl250_channel_and_sfo_estimation_params.h atpl250_reed_solomon.h atpl250_channel_estimation.h atpl250_common.h atpl250_carrier_mapping.h atpl250_mod_demod.h atpl250_reg.h
  group thirdparty/g3/phy/atpl250/module_config
    ../../../../phy/atpl250/module_config/: conf_fw.h conf_hw.h
  group thirdparty/g3/mac_rt/source
    ../../../../mac_rt/source/: MacRtMib.c MacRtConstants.c MacRt.c MacRtVersion.h MacPhyInterface.h
  group thirdparty/g3/mac_rt/include
    ../../../../mac_rt/include/: MacRtConstants.h MacRt.h MacRtDefs.h MacRtMib.h
  group thirdparty/g3/apps
    ../../../: conf_global.h
  group thirdparty/g3/apps/dlms_app_coord
    ../../: app_dlms_coord.c app_dispatcher.c main.c app_ping_coord.c dlms_cli_data.c app_udp_responder.c app_adp_mng.c ipv6_mng.c app_dlms_coord.h app_adp_mng.h g3_app_config.h app_ping_coord.h app_udp_responder.h dlms_cli_data.h ipv6_mng.h app_dispatcher.h
  group thirdparty/g3/apps/dlms_app_coord/samg55j19_atpl250ch_multiband
    ../: conf_tables.h conf_busart_if.h conf_buart_if.h conf_usi.h conf_hal.h conf_project.h FreeRTOSConfig.h conf_clock.h conf_usb.h conf_sleepmgr.h conf_pplc_if.h conf_bs.h conf_oss.h conf_board.h conf_uart_serial.h
  group thirdparty/g3/apps/dlms_app_coord/samg55j19_atpl250ch_multiband/iar
    ./: asf.h
  group thirdparty/g3/pal/atpl250_g3mac/source
    ../../../../pal/atpl250_g3mac/source/: pal.c
  group thirdparty/g3/pal/atpl250_g3mac/include
    ../../../../pal/atpl250_g3mac/include/: pal.h
  group thirdparty/g3/oss
    ../../../../oss/: oss_if.c oss_if.h
  group thirdparty/g3/adp
    ../../../../adp/: AdpConf.c
  group thirdparty/g3/adp/include
    ../../../../adp/include/: AdpApiTypes.h AdpSharedTypes.h AdpApi.h
  group thirdparty/g3/routing_wrapper/source
    ../../../../routing_wrapper/source/: RoutingWrapper.c
  group thirdparty/g3/routing_wrapper/include
    ../../../../routing_wrapper/include/: RoutingApi.h RoutingTypes.h
  group thirdparty/g3/storage
    ../../../../storage/: storage.c storage.h
  group thirdparty/g3/bootstrap_wrapper/source
    ../../../../bootstrap_wrapper/source/: BootstrapWrapper.c
  group thirdparty/g3/bootstrap_wrapper/include
    ../../../../bootstrap_wrapper/include/: BootstrapWrapper.h
  group thirdparty/g3/mac_wrapper/source
    ../../../../mac_wrapper/source/: mac_wrapper.c
  group thirdparty/g3/mac_wrapper/include
    ../../../../mac_wrapper/include/: mac_wrapper_defs.h mac_wrapper.h
  group thirdparty/g3/mac/include
    ../../../../mac/include/: MacApi.h MacMib.h MacDefs.h
  group thirdparty/g3/routing_loadng/include
    ../../../../routing_loadng/include/: ProtoLoadNg.h
  group thirdparty/dlms/libs/iar
    ../../../../../dlms/libs/iar/: libsamM4-dlms-client-iar.a
  group thirdparty/dlms/client/profile_g3
    ../../../../../dlms/client/profile_g3/: dlms_cli_data_example.c dlms_cli_data_example.h
  group thirdparty/dlms/client/lib
    ../../../../../dlms/client/lib/: dlms_cli_lib.h dlms_cli_cnf.h dlms_cli_types.h
  group thirdparty/cycloneTCP/cyclone_tcp/core
    ../../../../../cycloneTCP/cyclone_tcp/core/: tcp_timer.c tcp.c ethernet_misc.c udp.c ip.c tcp_misc.c nic.c ethernet.c raw_socket.c net_mem.c net.c socket.c ping.c tcp_fsm.c tcp.h nic.h ethernet.h net.h ethernet_misc.h ip.h udp.h tcp_fsm.h net_mem.h raw_socket.h net_legacy.h tcp_timer.h tcp_misc.h socket.h ping.h
  group thirdparty/cycloneTCP/cyclone_tcp/mibs
    ../../../../../cycloneTCP/cyclone_tcp/mibs/: mib2_module.c udp_mib_module.c udp_mib_impl.c tcp_mib_impl.c tcp_mib_module.c ip_mib_impl.c mib_common.c mib2_impl.c ip_mib_module.c udp_mib_module.h udp_mib_impl.h ip_mib_impl.h mib_common.h tcp_mib_module.h tcp_mib_impl.h mib2_impl.h ip_mib_module.h mib2_module.h if_mib_module.h
  group thirdparty/cycloneTCP/cyclone_tcp/dns
    ../../../../../cycloneTCP/cyclone_tcp/dns/: dns_cache.c dns_common.c dns_debug.c dns_client.c dns_debug.h dns_cache.h dns_client.h dns_common.h
  group thirdparty/cycloneTCP/cyclone_tcp/mdns
    ../../../../../cycloneTCP/cyclone_tcp/mdns/: mdns_common.c mdns_responder.c mdns_client.c mdns_responder.h mdns_common.h mdns_client.h
  group thirdparty/cycloneTCP/cyclone_tcp/dns_sd
    ../../../../../cycloneTCP/cyclone_tcp/dns_sd/: dns_sd.c dns_sd.h
  group thirdparty/cycloneTCP/cyclone_tcp/ppp
    ../../../../../cycloneTCP/cyclone_tcp/ppp/: pap.c ppp_fsm.c lcp.c chap.c ipv6cp.c ppp_debug.c ppp_hdlc.c ppp_misc.c ppp.c ipv6cp.h ppp_fsm.h ipcp.h ppp_debug.h lcp.h ppp_hdlc.h chap.h ppp_misc.h ppp.h pap.h
  group thirdparty/cycloneTCP/cyclone_tcp/ipv6
    ../../../../../cycloneTCP/cyclone_tcp/ipv6/: mld.c ipv6_frag.c ipv6_routing.c ipv6_misc.c ipv6.c ndp_misc.c ipv6_pmtu.c icmpv6.c ndp.c ndp_router_adv.c slaac.c ndp_cache.c ipv6_misc.h ndp.h ipv6.h ndp_cache.h ipv6_pmtu.h mld.h ipv6_routing.h ndp_router_adv.h icmpv6.h slaac.h ipv6_frag.h ndp_misc.h
  group thirdparty/cycloneTCP/cyclone_tcp/drivers
    ../../../../../cycloneTCP/cyclone_tcp/drivers/: plc_buart.c plc_buart.h
  group thirdparty/cycloneTCP/cyclone_tcp/drivers/g3
    ../../../../../cycloneTCP/cyclone_tcp/drivers/g3/: network_adapter_g3.c network_adapter_g3.h
  group thirdparty/cycloneTCP/cyclone_tcp/dhcpv6
    ../../../../../cycloneTCP/cyclone_tcp/dhcpv6/: dhcpv6_client.h dhcpv6_common.h
  group thirdparty/cycloneTCP/cyclone_tcp/llmnr
    ../../../../../cycloneTCP/cyclone_tcp/llmnr/: llmnr_responder.h llmnr_client.h llmnr_common.h
  group thirdparty/cycloneTCP/cyclone_tcp/ipv4
    ../../../../../cycloneTCP/cyclone_tcp/ipv4/: arp.h ipv4_frag.h auto_ip.h ipv4_misc.h igmp.h ipv4.h icmp.h ipv4_routing.h
  group thirdparty/cycloneTCP/cyclone_tcp/netbios
    ../../../../../cycloneTCP/cyclone_tcp/netbios/: nbns_common.h nbns_responder.h nbns_client.h
  group thirdparty/cycloneTCP/cyclone_tcp/dhcp
    ../../../../../cycloneTCP/cyclone_tcp/dhcp/: dhcp_common.h dhcp_client.h dhcp_server.h
  group thirdparty/cycloneTCP/cyclone_crypto/encoding
    ../../../../../cycloneTCP/cyclone_crypto/encoding/: oid.c asn1.c asn1.h oid.h
  group thirdparty/cycloneTCP/cyclone_crypto/mpi
    ../../../../../cycloneTCP/cyclone_crypto/mpi/: mpi.h
  group thirdparty/cycloneTCP/cyclone_crypto/core
    ../../../../../cycloneTCP/cyclone_crypto/core/: crypto_legacy.h crypto.h
  group thirdparty/cycloneTCP/common
    ../../../../../cycloneTCP/common/: date_time.c str.c cpu_endian.c os_port_none.c debug.c path.c path.h compiler_port.h error.h date_time.h os_port_none.h os_port.h cpu_endian.h fs_port.h debug.h str.h
  group thirdparty/cycloneTCP/atpl_extension
    ../../../../../cycloneTCP/atpl_extension/: async_ping.c async_ping.h
  group thirdparty/cycloneTCP/module_config
    ../../../../../cycloneTCP/module_config/: fs_port_config.h crypto_config.h net_config.h os_port_config.h
  group thirdparty/mbed-tls/library
    ../../../../../mbed-tls/library/: memory_buffer_alloc.c aesni.c cipher.c error.c ccm.c cipher_wrap.c debug_tls.c platform.c version.c aes_tls.c cmac.c timing.c oid_tls.c version_features.c gcm.c platform_util.c cipher_wrap.h common.h aesni.h
  group thirdparty/mbed-tls/include/mbedtls
    ../../../../../mbed-tls/include/mbedtls/: ctr_drbg.h pk.h cipher.h entropy.h timing.h error.h build_info.h compat-2.x.h ccm.h cmac.h md.h base64.h asn1.h mbedtls_config.h bignum.h platform.h platform_time.h ecp.h platform_util.h memory_buffer_alloc.h gcm.h version.h aes.h sha256.h threading.h debug.h oid.h private_access.h check_config.h ssl.h ssl_ciphersuites.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../freertos/freertos-7.3.0/source/: tasks.c timers.c FreeRTOS_CLI.c list.c queue.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f
    ../../../../../freertos/freertos-7.3.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../freertos/freertos-7.3.0/source/include/: task.h portable.h projdefs.h queue.h StackMacros.h semphr.h FreeRTOS_CLI.h mpu_wrappers.h timers.h list.h FreeRTOS.h croutine.h
  group sam/services/plc/buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/usi
    ../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/plc/busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/plc/pplc_if/atpl250_multiband
    ../../../../../../sam/services/plc/pplc_if/atpl250_multiband/: pplc_if.c pplc_if.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/adc
    ../../../../../../sam/drivers/adc/: adc2.c adc2.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../../sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../../sam/utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../../sam/utils/cmsis/samg/samg55/include/: samg55g19.h system_samg55.h samg55n19.h samg55j18.h samg55g18.h samg55.h samg55j19.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../../sam/utils/cmsis/samg/samg55/include/instance/: usart7.h usart5.h usart3.h usart1.h efc.h flexcom5.h pmc.h flexcom3.h flexcom1.h udp.h mem2mem.h gpbr.h twi5.h twi7.h i2sc0.h piob.h rtt.h twi3.h rstc.h twi1.h spi4.h tc1.h spi6.h spi0.h spi2.h cmcc.h usart6.h usart4.h usart2.h usart0.h pdmic1.h wdt.h uhp.h supc.h crccu.h flexcom7.h flexcom0.h flexcom6.h pdmic0.h pioa.h adc.h rtc.h flexcom2.h flexcom4.h twi6.h spi5.h spi7.h matrix.h tc0.h spi1.h spi3.h i2sc1.h chipid.h twi2.h twi0.h twi4.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../../sam/utils/cmsis/samg/samg55/include/component/: cmcc.h rstc.h i2sc.h pio.h mem2mem.h spi.h chipid.h pmc.h matrix.h udp.h rtt.h twi.h crccu.h gpbr.h uhp.h rtc.h supc.h efc.h flexcom.h adc.h pdmic.h pdc.h usart.h tc.h wdt.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../../sam/utils/cmsis/samg/samg55/include/pio/: samg55g18.h samg55j19.h samg55g19.h samg55n19.h samg55j18.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h mrepeat.h tpaste.h stringz.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/boards/atpl250ch
    ../../../../../../sam/boards/atpl250ch/: init.c atpl250ch.h led.h
  group common/utils
    ../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h sysclk.h pll.h genclk.h
  group common/services/clock/samg
    ../../../../../../common/services/clock/samg/: sysclk.c pll.h genclk.h sysclk.h osc.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
