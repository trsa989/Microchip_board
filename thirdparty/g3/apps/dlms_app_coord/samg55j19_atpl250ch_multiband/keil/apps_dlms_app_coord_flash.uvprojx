# Keil uVision project apps_dlms_app_coord_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAMG55J19 Atmel
  pack: Keil.SAMG_DFP.1.1.0
  cpu: IROM(0x00400000,0x80000) IRAM(0x20000000,0x28000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: apps_template_app
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: __G3_STACK__ __FREERTOS__ BOARD=ATPL250CH __SAMG55J19__ ARM_MATH_CM4=true
  c misc: --diag_suppress=66
  c include: ..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\routing_wrapper\source;..\..\..\..\..\..\sam\services\plc\pcrc;..\..\..\..\..\..\sam\utils\fpu;..\..\..\..\..\..\sam\services\plc\buart_if;..\..\..\..\mac\include;..\..\..\..\..\..\common\services\ioport;..\..\..;..\..\..\..\coordinator\include;..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\include;..\..\..\..\..\cycloneTCP\cyclone_crypto;..\..\..\..\..\..\sam\utils;..\..\..\..\routing_loadng\source;..\..\..\..\routing_wrapper\include;..\..\..\..\..\..\common\boards;..\..\..\..\..\dlms\client\profile_g3;..\..\..\..\bootstrap_wrapper\source;..\..\..\..\..\..\sam\drivers\pdc;..\..\..\..\..\..\sam\boards;..\..\..\..\adp\include;..\..\..\..\common\source;..\..\..\..\..\dlms\client\lib;..\..\..\..\..\..\sam\drivers\adc;..\..\..\..\..\..\sam\drivers\pmc;..\..\..\..\..\cycloneTCP\cyclone_tcp;..\..\..\..\..\..\sam\services\plc\pplc_if\atpl250_multiband;..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\source\templates;..\..\..\..\routing_loadng\include;..\..\..\..\..\..\sam\drivers\gpbr;..\..\..\..\..\..\common\utils;..\..\..\..\..\..\sam\drivers\pio;..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\bootstrap_lbp\source;..\..\..\..\..\mbed-tls\library;..\..\..\..\phy\atpl250\include_multiband;..;..\..\..\..\..\..\sam\drivers\supc;..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\phy\atpl250\addons\sniffer_if;..\..\..\..\..\freertos\freertos-7.3.0\source\include;..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\mac_rt\source;..\..\..\..\oss;..\..\..\..\..\..\common\services\clock;..\..\..\..\..\..\sam\drivers\flexcom;..\..\..\..\phy\atpl250\module_config;..\..\..\..\bootstrap_wrapper\include;..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f;..\..\..\..\..\..\sam\services\plc\usi;..\..\..\..\..\..\common\services\sleepmgr;..\..\..\..\..\..\common\services\gpio;..\..\..\..\common\include;..\..\..\..\..\..\sam\utils\header_files;..\..\..\..;..\..\..\..\..\cycloneTCP\module_config;..\..\..\..\..\..\common\services\serial\sam_uart;..\..\..\..\..\cycloneTCP\atpl_extension;..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\sam\boards\atpl250ch;..\..\..\..\..\..\sam\services\plc\busart_if;..\..\..\..\coordinator\source;..\..\..\..\pal\atpl250_g3mac\include;..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\..\sam\drivers\usart;..\..\..\..\..\..\sam\services\flash_efc;..\..\..\..\bootstrap_lbp\include;..\..\..\..\mac_wrapper\include;..\..\..\..\..\cycloneTCP\common;..\..\..\..\..\mbed-tls\include;..\..;..\..\..\..\mac_rt\include;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x400000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\samg55j19.sct
  group Startup
    ./: startup_SAMG55.s retarget.c system_samg55.c
  group thirdparty_g3_libs_keil
    ../../../../libs/keil/: lib-g3-keil-loadng.lib lib-g3-keil-mac.lib lib-g3-keil-adp.lib
  group thirdparty_g3_common_source
    ../../../../common/source/: Logger.c Timer.c Random.c Byte.c QueueMng.c
  group thirdparty_g3_crypto
    ../../../../crypto/: aes_wrapper.c cipher_wrapper.c eax.c
  group thirdparty_g3_bootstrap_lbp_source
    ../../../../bootstrap_lbp/source/: ProcessLbp.c ProtoEapPsk.c ProtoLbp.c
  group thirdparty_g3_coordinator_source
    ../../../../coordinator/source/: bs_functions.c bs_main.c
  group thirdparty_g3_hal_SAM
    ../../../../hal/SAM/: hal.c
  group thirdparty_g3_phy_atpl250_addons_sniffer_if
    ../../../../phy/atpl250/addons/sniffer_if/: sniffer_if.c
  group thirdparty_g3_phy_atpl250_source_multiband
    ../../../../phy/atpl250/source_multiband/: atpl250_ber.c atpl250_modulator.S atpl250_sampling_error_estimation_as.S atpl250.c atpl250_channel_estimation.c atpl250_reed_solomon.c atpl250_hw_init.c atpl250_jump_ram.c atpl250_fch.c atpl250_txrx_chain.c atpl250_aux_func_as.S atpl250_demodulator.S atpl250_mod_demod.c atpl250_carrier_mapping.c atpl250_sampling_error_estimation.c atpl250_channel_estimation_as.S
  group thirdparty_g3_mac_rt_source
    ../../../../mac_rt/source/: MacRtMib.c MacRtConstants.c MacRt.c
  group thirdparty_g3_apps_dlms_app_coord
    ../../: app_dlms_coord.c app_dispatcher.c main.c app_ping_coord.c dlms_cli_data.c app_udp_responder.c app_adp_mng.c ipv6_mng.c
  group thirdparty_g3_pal_atpl250_g3mac_source
    ../../../../pal/atpl250_g3mac/source/: pal.c
  group thirdparty_g3_oss
    ../../../../oss/: oss_if.c
  group thirdparty_g3_adp
    ../../../../adp/: AdpConf.c
  group thirdparty_g3_routing_wrapper_source
    ../../../../routing_wrapper/source/: RoutingWrapper.c
  group thirdparty_g3_storage
    ../../../../storage/: storage.c
  group thirdparty_g3_bootstrap_wrapper_source
    ../../../../bootstrap_wrapper/source/: BootstrapWrapper.c
  group thirdparty_g3_mac_wrapper_source
    ../../../../mac_wrapper/source/: mac_wrapper.c
  group thirdparty_dlms_libs_keil
    ../../../../../dlms/libs/keil/: libsamM4-dlms-client-keil.lib
  group thirdparty_dlms_client_profile_g3
    ../../../../../dlms/client/profile_g3/: dlms_cli_data_example.c
  group thirdparty_cycloneTCP_cyclone_tcp_core
    ../../../../../cycloneTCP/cyclone_tcp/core/: tcp_timer.c tcp.c ethernet_misc.c udp.c ip.c tcp_misc.c nic.c ethernet.c raw_socket.c net_mem.c net.c socket.c ping.c tcp_fsm.c
  group thirdparty_cycloneTCP_cyclone_tcp_mibs
    ../../../../../cycloneTCP/cyclone_tcp/mibs/: mib2_module.c udp_mib_module.c udp_mib_impl.c tcp_mib_impl.c tcp_mib_module.c ip_mib_impl.c mib_common.c mib2_impl.c ip_mib_module.c
  group thirdparty_cycloneTCP_cyclone_tcp_dns
    ../../../../../cycloneTCP/cyclone_tcp/dns/: dns_cache.c dns_common.c dns_debug.c dns_client.c
  group thirdparty_cycloneTCP_cyclone_tcp_mdns
    ../../../../../cycloneTCP/cyclone_tcp/mdns/: mdns_common.c mdns_responder.c mdns_client.c
  group thirdparty_cycloneTCP_cyclone_tcp_dns_sd
    ../../../../../cycloneTCP/cyclone_tcp/dns_sd/: dns_sd.c
  group thirdparty_cycloneTCP_cyclone_tcp_ppp
    ../../../../../cycloneTCP/cyclone_tcp/ppp/: pap.c ppp_fsm.c lcp.c chap.c ipv6cp.c ppp_debug.c ppp_hdlc.c ppp_misc.c ppp.c
  group thirdparty_cycloneTCP_cyclone_tcp_ipv6
    ../../../../../cycloneTCP/cyclone_tcp/ipv6/: mld.c ipv6_frag.c ipv6_routing.c ipv6_misc.c ipv6.c ndp_misc.c ipv6_pmtu.c icmpv6.c ndp.c ndp_router_adv.c slaac.c ndp_cache.c
  group thirdparty_cycloneTCP_cyclone_tcp_drivers
    ../../../../../cycloneTCP/cyclone_tcp/drivers/: plc_buart.c
    ../../../../../cycloneTCP/cyclone_tcp/drivers/g3/: network_adapter_g3.c
  group thirdparty_cycloneTCP_cyclone_crypto_encoding
    ../../../../../cycloneTCP/cyclone_crypto/encoding/: oid.c asn1.c
  group thirdparty_cycloneTCP_common
    ../../../../../cycloneTCP/common/: date_time.c str.c cpu_endian.c os_port_none.c debug.c path.c
  group thirdparty_cycloneTCP_atpl_extension
    ../../../../../cycloneTCP/atpl_extension/: async_ping.c
  group thirdparty_mbed-tls_library
    ../../../../../mbed-tls/library/: memory_buffer_alloc.c aesni.c cipher.c error.c ccm.c cipher_wrap.c debug_tls.c platform.c version.c aes_tls.c cmac.c timing.c oid_tls.c version_features.c gcm.c platform_util.c
  group sam_services_plc_buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c
  group sam_services_plc_pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c
  group sam_services_plc_usi
    ../../../../../../sam/services/plc/usi/: usi.c
  group sam_services_plc_busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c
  group sam_services_plc_pplc_if_atpl250_multiband
    ../../../../../../sam/services/plc/pplc_if/atpl250_multiband/: pplc_if.c
  group sam_services_flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c
  group sam_drivers_pdc
    ../../../../../../sam/drivers/pdc/: pdc.c
  group sam_drivers_tc
    ../../../../../../sam/drivers/tc/: tc.c
  group sam_drivers_flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c
  group sam_drivers_efc
    ../../../../../../sam/drivers/efc/: efc.c
  group sam_drivers_supc
    ../../../../../../sam/drivers/supc/: supc.c
  group sam_drivers_spi
    ../../../../../../sam/drivers/spi/: spi.c
  group sam_drivers_pmc
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam_drivers_usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam_drivers_pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam_drivers_adc
    ../../../../../../sam/drivers/adc/: adc2.c
  group sam_drivers_gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c
  group sam_boards_atpl250ch
    ../../../../../../sam/boards/atpl250ch/: init.c
  group common_utils_stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common_utils_interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common_services_sleepmgr_sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group common_services_clock_samg
    ../../../../../../common/services/clock/samg/: sysclk.c
  group common_services_serial
    ../../../../../../common/services/serial/: usart_serial.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
