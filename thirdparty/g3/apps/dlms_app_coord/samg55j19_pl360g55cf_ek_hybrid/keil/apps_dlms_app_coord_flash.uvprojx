# Keil uVision project apps_dlms_app_coord_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAMG55J19 Atmel
  pack: Keil.SAMG_DFP.1.1.0
  cpu: IROM(0x00400000,0x80000) IRAM(0x20000000,0x28000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: apps_template_app
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: __G3_STACK__ __SAMG55J19__ UDD_ENABLE BOARD=PL360G55CF_EK G3_HYBRID_PROFILE __FREERTOS__ ARM_MATH_CM4=true
  c misc: --diag_suppress=66 --gnu
  c include: ..\..\..\..\routing_wrapper\source;..\..\..\..\..\..\sam\services\plc\usi;..\..\..\..\..\..\common\services\ioport;..\..\..\..\..\..\common\services\usb\class\cdc\device;..\..\..\..\..\freertos\freertos-7.3.0\source\include;..\..\..\..\..\..\common\services\usb;..\..\..\..\phy\atpl360\coup_tx_config;..\..\..\..\routing_loadng\include;..\..\..\..\..\cycloneTCP\cyclone_crypto;..\..\..\..\..\..\sam\boards;..\..\..\..\adp\include;..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\source\templates;..\..\..\..\..\..\common\utils;..\..\..\..\..\..\sam\drivers\pio;..\..\..\..\pal_rf\rf215_g3mac\include;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_tx_rx;..\..\..\..\..\dlms\client\lib;..\..\..\..\..\..\common\components\rf\at86rf215\addons\sniffer_if\g3;..\..\..\..\..\mbed-tls\include;..\..\..\..\..\..\sam\services\plc\usb_wrp;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_bbc;..\..\..\..\coordinator\source;..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\..\sam\services\flash_efc;..\..\..\..\..\cycloneTCP\common;..\..\..\..\..\..\common\utils\stdio\stdio_udc;..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\coordinator\include;..\..\..\..\..\..\sam\utils;..\..\..\..\routing_loadng\source;..\..\..\..\..\..\sam\drivers\udp;..\..\..\..\mac_rt\include;..\..\..\..\bootstrap_wrapper\source;..\..\..\..\..\..\sam\drivers\pdc;..\..\..\..\common\source;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_pll;..\..\..\..\mac_rf\include;..\..\..\..\..\cycloneTCP\cyclone_tcp;..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl360_cen_a_fcc;..\..\..\..\oss;..\..\..\..\..\..\sam\drivers\flexcom;..\..\..\..\bootstrap_wrapper\include;..\..\..\..\..\..\sam\utils\header_files;..\..\..\..;..\..\..\..\..\cycloneTCP\module_config;..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360;..\..;..\..\..\..\..\..\sam\services\plc\pcrc;..\..\..\..\..\..\sam\services\plc\buart_if;..\..\..;..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\include;..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f;..\..\..\..\routing_wrapper\include;..\..\..\..\..\..\sam\drivers\wdt;..\..\..\..\..\..\sam\boards\pl360g55cf_ek;..\..\..\..\..\..\sam\drivers\pmc;..\..\..\..\..\..\common\components\rf\at86rf215\addons;..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\mac\include;..\..\..\..\pal\atpl360_g3macrt\include;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt;..\..\..\..\..\..\common\services\gpio;..\..\..\..\..\..\sam\drivers\matrix;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_common;..\..\..\..\..\cycloneTCP\atpl_extension;..;..\..\..\..\bootstrap_lbp\include;..\..\..\..\..\..\common\services\sleepmgr;..\..\..\..\phy\atpl360\coup_tx_config\coup_params;..\..\..\..\..\..\sam\utils\fpu;..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt;..\..\..\..\..\..\common\boards;..\..\..\..\..\dlms\client\profile_g3;..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\..\..\common\services\usb\udc;..\..\..\..\..\..\sam\services\plc\busart_if;..\..\..\..\..\..\sam\drivers\adc;..\..\..\..\hyal\include;..\..\..\..\..\..\sam\drivers\gpbr;..\..\..\..\..\..\common\services\delay;..\..\..\..\..\..\common\services\usb\class\cdc;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_irq;..\..\..\..\bootstrap_lbp\source;..\..\..\..\..\..\common\components\rf\at86rf215;..\..\..\..\..\mbed-tls\library;..\..\..\..\..\..\sam\services\timer_1us;..\..\..\..\..\..\sam\drivers\supc;..\..\..\..\..\..\common\services\clock;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_fe;..\..\..\..\common\include;..\..\..\..\..\..\common\services\serial\sam_uart;..\..\..\..\..\..\sam\services\rf\prf_if\at86rf215;..\..\..\..\mac_wrapper\include;..\..\..\..\..\..\sam\drivers\usart;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x400000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\samg55j19.sct
  group Startup
    ./: startup_SAMG55.s retarget.c system_samg55.c atpl_bin_multi.S
  group thirdparty_g3_libs_keil
    ../../../../libs/keil/: lib-g3-keil-mac-rf.lib lib-g3-keil-mac.lib lib-g3-keil-loadng-hyb.lib lib-g3-keil-adp-hyb.lib
  group thirdparty_g3_pal_rf_rf215_g3mac_source
    ../../../../pal_rf/rf215_g3mac/source/: pal_rf.c
  group thirdparty_g3_common_source
    ../../../../common/source/: Logger.c Byte.c Timer.c Random.c QueueMng.c
  group thirdparty_g3_crypto
    ../../../../crypto/: eax.c aes_wrapper.c cipher_wrapper.c
  group thirdparty_g3_coordinator_source
    ../../../../coordinator/source/: bs_functions.c bs_main.c
  group thirdparty_g3_apps_dlms_app_coord
    ../../: app_adp_mng.c app_dlms_coord.c app_dispatcher.c main.c app_ping_coord.c dlms_cli_data.c app_udp_responder.c ipv6_mng.c
  group thirdparty_g3_oss
    ../../../../oss/: oss_if.c
  group thirdparty_g3_bootstrap_lbp_source
    ../../../../bootstrap_lbp/source/: ProtoEapPsk.c ProtoLbp.c ProcessLbp.c
  group thirdparty_g3_phy_atpl360_coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c
  group thirdparty_g3_hal_SAM_atpl360
    ../../../../hal/SAM_atpl360/: hal.c
  group thirdparty_g3_pal_atpl360_g3macrt_source
    ../../../../pal/atpl360_g3macrt/source/: pal.c
  group thirdparty_g3_bootstrap_wrapper_source
    ../../../../bootstrap_wrapper/source/: BootstrapWrapper.c
  group thirdparty_g3_adp
    ../../../../adp/: AdpConf.c
  group thirdparty_g3_routing_wrapper_source
    ../../../../routing_wrapper/source/: RoutingWrapper.c
  group thirdparty_g3_storage
    ../../../../storage/: storage.c
  group thirdparty_g3_hyal_source
    ../../../../hyal/source/: hyal.c
  group thirdparty_g3_mac_wrapper_source
    ../../../../mac_wrapper/source/: mac_wrapper.c
  group thirdparty_dlms_libs_keil
    ../../../../../dlms/libs/keil/: libsamM4-dlms-client-keil.lib
  group thirdparty_dlms_client_profile_g3
    ../../../../../dlms/client/profile_g3/: dlms_cli_data_example.c
  group thirdparty_cycloneTCP_cyclone_crypto_encoding
    ../../../../../cycloneTCP/cyclone_crypto/encoding/: oid.c asn1.c
  group thirdparty_cycloneTCP_cyclone_tcp_core
    ../../../../../cycloneTCP/cyclone_tcp/core/: tcp.c tcp_timer.c ethernet_misc.c net_mem.c ip.c tcp_misc.c nic.c ethernet.c raw_socket.c net.c socket.c ping.c tcp_fsm.c udp.c
  group thirdparty_cycloneTCP_cyclone_tcp_mibs
    ../../../../../cycloneTCP/cyclone_tcp/mibs/: mib2_module.c tcp_mib_impl.c udp_mib_module.c udp_mib_impl.c tcp_mib_module.c ip_mib_impl.c mib_common.c mib2_impl.c ip_mib_module.c
  group thirdparty_cycloneTCP_cyclone_tcp_dns
    ../../../../../cycloneTCP/cyclone_tcp/dns/: dns_cache.c dns_common.c dns_debug.c dns_client.c
  group thirdparty_cycloneTCP_cyclone_tcp_mdns
    ../../../../../cycloneTCP/cyclone_tcp/mdns/: mdns_common.c mdns_responder.c mdns_client.c
  group thirdparty_cycloneTCP_cyclone_tcp_dns_sd
    ../../../../../cycloneTCP/cyclone_tcp/dns_sd/: dns_sd.c
  group thirdparty_cycloneTCP_cyclone_tcp_ppp
    ../../../../../cycloneTCP/cyclone_tcp/ppp/: pap.c ppp_fsm.c lcp.c chap.c ipv6cp.c ppp_debug.c ppp_hdlc.c ppp_misc.c ppp.c
  group thirdparty_cycloneTCP_cyclone_tcp_ipv6
    ../../../../../cycloneTCP/cyclone_tcp/ipv6/: mld.c ipv6_frag.c ipv6_routing.c ipv6_misc.c ipv6.c ndp_misc.c ipv6_pmtu.c icmpv6.c ndp.c ndp_router_adv.c slaac.c ndp_cache.c
  group thirdparty_cycloneTCP_cyclone_tcp_drivers
    ../../../../../cycloneTCP/cyclone_tcp/drivers/: plc_buart.c
    ../../../../../cycloneTCP/cyclone_tcp/drivers/g3/: network_adapter_g3.c
  group thirdparty_cycloneTCP_common
    ../../../../../cycloneTCP/common/: date_time.c debug.c str.c cpu_endian.c os_port_none.c path.c
  group thirdparty_cycloneTCP_atpl_extension
    ../../../../../cycloneTCP/atpl_extension/: async_ping.c
  group mbed-tls_library
    ../../../../../mbed-tls/library/: aesni.c cipher.c error.c ccm.c cipher_wrap.c debug_tls.c platform.c version.c aes_tls.c memory_buffer_alloc.c cmac.c timing.c oid_tls.c version_features.c gcm.c platform_util.c
  group sam_services_plc_buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c
  group sam_services_plc_usb_wrp
    ../../../../../../sam/services/plc/usb_wrp/: usb_wrp.c
  group sam_services_plc_pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c
  group sam_services_plc_pplc_if_atpl360
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c
  group sam_services_plc_usi
    ../../../../../../sam/services/plc/usi/: usi.c
  group sam_services_plc_busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c
  group sam_services_timer_1us
    ../../../../../../sam/services/timer_1us/: timer_1us.c
    ../../../../../../sam/services/timer_1us/hal_samg55/: timer_1us_hal.c
  group sam_services_rf_prf_if_at86rf215
    ../../../../../../sam/services/rf/prf_if/at86rf215/: prf_if.c
  group sam_services_flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c
  group sam_drivers_matrix
    ../../../../../../sam/drivers/matrix/: matrix.c
  group sam_drivers_pdc
    ../../../../../../sam/drivers/pdc/: pdc.c
  group sam_drivers_tc
    ../../../../../../sam/drivers/tc/: tc.c
  group sam_drivers_flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c
  group sam_drivers_wdt
    ../../../../../../sam/drivers/wdt/: wdt.c
  group sam_drivers_efc
    ../../../../../../sam/drivers/efc/: efc.c
  group sam_drivers_supc
    ../../../../../../sam/drivers/supc/: supc.c
  group sam_drivers_udp
    ../../../../../../sam/drivers/udp/: udp_device.c
  group sam_drivers_pmc
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam_drivers_usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam_drivers_pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam_drivers_adc
    ../../../../../../sam/drivers/adc/: adc2.c
  group sam_drivers_spi
    ../../../../../../sam/drivers/spi/: spi.c
  group sam_drivers_gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c
  group sam_boards_pl360g55cf_ek
    ../../../../../../sam/boards/pl360g55cf_ek/: init.c
  group common_components_rf_at86rf215_rf215_irq
    ../../../../../../common/components/rf/at86rf215/rf215_irq/: rf215_irq.c
  group common_components_rf_at86rf215_rf215_common
    ../../../../../../common/components/rf/at86rf215/rf215_common/: rf215_spi.c rf215_trx_ctl.c
  group common_components_rf_at86rf215_rf215_tx_rx
    ../../../../../../common/components/rf/at86rf215/rf215_tx_rx/: rf215_rx.c rf215_tx.c
  group common_components_rf_at86rf215_rf215_bbc
    ../../../../../../common/components/rf/at86rf215/rf215_bbc/: rf215_bbc.c
  group common_components_rf_at86rf215_rf215_fe
    ../../../../../../common/components/rf/at86rf215/rf215_fe/: rf215_fe.c
  group common_components_rf_at86rf215
    ../../../../../../common/components/rf/at86rf215/: at86rf215.c
    ../../../../../../common/components/rf/at86rf215/rf215_pll/: rf215_pll.c
  group common_components_rf_at86rf215_addons_sniffer_if_g3
    ../../../../../../common/components/rf/at86rf215/addons/sniffer_if/g3/: rf215_sniffer_if_g3.c
  group common_components_rf_at86rf215_addons_sniffer_if
    ../../../../../../common/components/rf/at86rf215/addons/sniffer_if/: rf215_sniffer_if.c
  group common_components_plc_atpl360_g3_mac_rt_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c
  group common_components_plc_atpl360_g3_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_boot.c atpl360_hal_spi.c atpl360.c
  group common_utils_stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common_utils_interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common_services_delay_sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c
  group common_services_clock_samg
    ../../../../../../common/services/clock/samg/: sysclk.c
  group common_services_usb_udc
    ../../../../../../common/services/usb/udc/: udc.c
  group common_services_usb_class_cdc_device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common_services_sleepmgr_sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group common_services_serial
    ../../../../../../common/services/serial/: usart_serial.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
