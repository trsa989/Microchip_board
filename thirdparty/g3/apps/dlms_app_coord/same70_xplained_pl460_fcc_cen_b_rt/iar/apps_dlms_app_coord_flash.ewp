# IAR project apps_dlms_app_coord_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21 Atmel ATSAME70Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __G3_STACK__; UDD_ENABLE; ARM_MATH_CM7=true; BOARD=SAME70_XPLAINED; __SAME70Q21B__; __FREERTOS__
  ICCARM.CCIncludePath2: ..\..\..\..\routing_wrapper\source; ..; ..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\common\services\usb\class\cdc\device; ..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\..\..\common\services\usb; ..\..\..\..\phy\atpl360\coup_tx_config; ..\..\..\..\..\..\sam\utils\cmsis\same70\include; ..\..\..\..\..\cycloneTCP\cyclone_crypto; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\services\plc\usi; ..\..\..\..\..\..\sam\drivers\usbhs; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt; ..\..\..\..\..\..\sam\services\plc\busart_if; ..\..\..\..\..\dlms\client\lib; ..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460_fcc_cen_b; ..\..\..\..\..\mbed-tls\include; ..\..\..\..\routing_wrapper\include; ..\..\..\..\..\..\sam\utils\cmsis\same70\source\templates; ..\..\..\..\coordinator\source; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\drivers\xdmac; ..\..\..\..\..\cycloneTCP\common; ..\..\..\..\..\..\common\utils\stdio\stdio_udc; ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\coordinator\include; ..\..\..\..\..\..\sam\utils; ..\..\..\..\routing_loadng\source; ..\..\..\..\mac_rt\include; ..\..\..\..\bootstrap_wrapper\source; ..\..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\cycloneTCP\cyclone_tcp; ..\..\..\..\..\..\sam\drivers\mpu; ..\..\..\..\oss; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\bootstrap_wrapper\include; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..; ..\..\..\..\..\cycloneTCP\module_config; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360; ..\..; ..\..\..\..\..\..\sam\services\plc\pcrc; ..\..\..\..\adp\include; ..\..\..; ..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f; ..\..\..\..\..\..\sam\services\plc\usb_wrp; ..\..\..\..\..\..\sam\drivers\wdt; ..\..\..\..\..\..\sam\services\plc\buart_if; ..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\pal\atpl360_g3macrt\include; ..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\sam\drivers\matrix; ..\..\..\..\..\cycloneTCP\atpl_extension; ..\..\..\..\bootstrap_lbp\include; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\phy\atpl360\coup_tx_config\coup_params; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt; ..\..\..\..\..\..\common\boards; ..\..\..\..\..\dlms\client\profile_g3; ..\..\..\..\..\..\common\services\usb\udc; ..\..\..\..\..\mbed-tls\sam_aes_alt; ..\..\..\..\mac\include; ..\..\..\..\..\..\sam\drivers\afec; ..\..\..\..\..\..\sam\boards\same70_xplained; ..\..\..\..\routing_loadng\include; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\common\services\usb\class\cdc; ..\..\..\..\bootstrap_lbp\source; ..\..\..\..\..\mbed-tls\library; ..\..\..\..\common\source; ..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\common\include; ..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\sam\drivers\rstc; ..\..\..\..\mac_wrapper\include; ..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_dlms_app_coord_flash.bin
  ILINK.IlinkOutputFile: apps_dlms_app_coord_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\sam\utils\linker_scripts\same70\same70q21\iar\flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_G3_MAC_RT_CENB.bin,atpl_bin_cenb,P_atpl_bin_cenb,8; --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_G3_MAC_RT_FCC.bin,atpl_bin_fcc,P_atpl_bin_fcc,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/g3/libs/iar
    ../../../../libs/iar/: lib-g3-iar-loadng.a lib-g3-iar-mac.a lib-g3-iar-adp.a
  group thirdparty/g3/common/source
    ../../../../common/source/: Logger.c Byte.c Timer.c Random.c QueueMng.c
  group thirdparty/g3/common/include
    ../../../../common/include/: g3_stack_version.h Byte.h Logger.h Random.h QueueMng.h Timer.h
  group thirdparty/g3/crypto
    ../../../../crypto/: aes_wrapper.c cipher_wrapper.c eax.c cipher_wrapper.h brg_endian.h brg_types.h aes_wrapper.h eax.h mode_hdr.h
  group thirdparty/g3/coordinator/source
    ../../../../coordinator/source/: bs_functions.c bs_main.c bs_functions.h
  group thirdparty/g3/coordinator/include
    ../../../../coordinator/include/: bs_api.h
  group thirdparty/g3/oss
    ../../../../oss/: oss_if.c oss_if.h
  group thirdparty/g3/apps
    ../../../: conf_global.h
  group thirdparty/g3/apps/dlms_app_coord
    ../../: app_dlms_coord.c app_dispatcher.c main.c app_ping_coord.c dlms_cli_data.c app_udp_responder.c app_adp_mng.c ipv6_mng.c app_dlms_coord.h app_adp_mng.h g3_app_config.h app_ping_coord.h app_udp_responder.h dlms_cli_data.h ipv6_mng.h app_dispatcher.h
  group thirdparty/g3/apps/dlms_app_coord/same70_xplained_pl460_fcc_cen_b_rt
    ../: conf_tables.h conf_busart_if.h conf_buart_if.h conf_usi.h conf_hal.h conf_project.h FreeRTOSConfig.h conf_clock.h conf_usb.h conf_sleepmgr.h conf_pplc_if.h conf_bs.h conf_atpl360.h conf_oss.h conf_uart_serial.h conf_board.h
  group thirdparty/g3/apps/dlms_app_coord/same70_xplained_pl460_fcc_cen_b_rt/iar
    ./: asf.h
  group thirdparty/g3/bootstrap_lbp/source
    ../../../../bootstrap_lbp/source/: ProtoEapPsk.c ProtoLbp.c ProcessLbp.c ProtoLbpVersion.h
  group thirdparty/g3/bootstrap_lbp/include
    ../../../../bootstrap_lbp/include/: ProtoLbp.h ProcessLbp.h ProtoEapPsk.h
  group thirdparty/g3/phy/atpl360/coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c coup_tx_config.h coup_defs.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_params
    ../../../../phy/atpl360/coup_tx_config/coup_params/: pl460_sb_fcc.h pl460_plcoup014_cen_b.h pl460_1_5b_fcc.h plcoup014_cen_b.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_conf/pl460_fcc_cen_b
    ../../../../phy/atpl360/coup_tx_config/coup_conf/pl460_fcc_cen_b/: coup_conf.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt
    ../../../../phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt/: coup_pl360_wrp.h
  group thirdparty/g3/hal
    ../../../../hal/: hal.h
  group thirdparty/g3/hal/SAM_atpl360
    ../../../../hal/SAM_atpl360/: hal.c hal.h
  group thirdparty/g3/pal/atpl360_g3macrt/source
    ../../../../pal/atpl360_g3macrt/source/: pal.c
  group thirdparty/g3/pal/atpl360_g3macrt/include
    ../../../../pal/atpl360_g3macrt/include/: pal.h
  group thirdparty/g3/adp
    ../../../../adp/: AdpConf.c
  group thirdparty/g3/adp/include
    ../../../../adp/include/: AdpApiTypes.h AdpSharedTypes.h AdpApi.h
  group thirdparty/g3/routing_wrapper/source
    ../../../../routing_wrapper/source/: RoutingWrapper.c
  group thirdparty/g3/routing_wrapper/include
    ../../../../routing_wrapper/include/: RoutingApi.h RoutingTypes.h
  group thirdparty/g3/storage
    ../../../../storage/: storage.c storage.h
  group thirdparty/g3/bootstrap_wrapper/source
    ../../../../bootstrap_wrapper/source/: BootstrapWrapper.c
  group thirdparty/g3/bootstrap_wrapper/include
    ../../../../bootstrap_wrapper/include/: BootstrapWrapper.h
  group thirdparty/g3/mac_wrapper/source
    ../../../../mac_wrapper/source/: mac_wrapper.c
  group thirdparty/g3/mac_wrapper/include
    ../../../../mac_wrapper/include/: mac_wrapper_defs.h mac_wrapper.h
  group thirdparty/g3/mac/include
    ../../../../mac/include/: MacApi.h MacMib.h MacDefs.h
  group thirdparty/g3/mac_rt/include
    ../../../../mac_rt/include/: MacRtConstants.h MacRtDefs.h MacRtMib.h MacRt.h
  group thirdparty/g3/routing_loadng/include
    ../../../../routing_loadng/include/: ProtoLoadNg.h
  group thirdparty/dlms/libs/iar
    ../../../../../dlms/libs/iar/: libsamM4-dlms-client-iar.a
  group thirdparty/dlms/client/profile_g3
    ../../../../../dlms/client/profile_g3/: dlms_cli_data_example.c dlms_cli_data_example.h
  group thirdparty/dlms/client/lib
    ../../../../../dlms/client/lib/: dlms_cli_lib.h dlms_cli_cnf.h dlms_cli_types.h
  group thirdparty/cycloneTCP/cyclone_tcp/core
    ../../../../../cycloneTCP/cyclone_tcp/core/: tcp_timer.c tcp.c ethernet_misc.c udp.c ip.c tcp_misc.c nic.c ethernet.c raw_socket.c net_mem.c net.c socket.c ping.c tcp_fsm.c tcp.h nic.h net.h ethernet_misc.h udp.h ethernet.h tcp_fsm.h net_mem.h raw_socket.h net_legacy.h tcp_timer.h tcp_misc.h ip.h socket.h ping.h
  group thirdparty/cycloneTCP/cyclone_tcp/mibs
    ../../../../../cycloneTCP/cyclone_tcp/mibs/: mib2_module.c udp_mib_module.c udp_mib_impl.c tcp_mib_impl.c tcp_mib_module.c ip_mib_impl.c mib_common.c mib2_impl.c ip_mib_module.c udp_mib_impl.h ip_mib_impl.h mib_common.h tcp_mib_module.h tcp_mib_impl.h udp_mib_module.h mib2_impl.h ip_mib_module.h mib2_module.h if_mib_module.h
  group thirdparty/cycloneTCP/cyclone_tcp/dns
    ../../../../../cycloneTCP/cyclone_tcp/dns/: dns_cache.c dns_common.c dns_debug.c dns_client.c dns_debug.h dns_cache.h dns_common.h dns_client.h
  group thirdparty/cycloneTCP/cyclone_tcp/mdns
    ../../../../../cycloneTCP/cyclone_tcp/mdns/: mdns_common.c mdns_responder.c mdns_client.c mdns_responder.h mdns_common.h mdns_client.h
  group thirdparty/cycloneTCP/cyclone_tcp/ppp
    ../../../../../cycloneTCP/cyclone_tcp/ppp/: pap.c ppp_fsm.c lcp.c chap.c ipv6cp.c ppp_debug.c ppp_hdlc.c ipcp.c ppp_misc.c ppp.c ipv6cp.h ppp_fsm.h ipcp.h lcp.h ppp_debug.h ppp_hdlc.h ppp_misc.h ppp.h chap.h pap.h
  group thirdparty/cycloneTCP/cyclone_tcp/ipv6
    ../../../../../cycloneTCP/cyclone_tcp/ipv6/: mld.c ipv6_frag.c ipv6_routing.c ipv6_misc.c ipv6.c ndp_misc.c ipv6_pmtu.c icmpv6.c ndp.c ndp_router_adv.c slaac.c ndp_cache.c ipv6_misc.h ndp.h ipv6.h ndp_router_adv.h mld.h ipv6_routing.h icmpv6.h slaac.h ndp_cache.h ipv6_frag.h ndp_misc.h ipv6_pmtu.h
  group thirdparty/cycloneTCP/cyclone_tcp/drivers
    ../../../../../cycloneTCP/cyclone_tcp/drivers/: plc_buart.c plc_buart.h
  group thirdparty/cycloneTCP/cyclone_tcp/drivers/phy
    ../../../../../cycloneTCP/cyclone_tcp/drivers/phy/: ksz8081_driver.c ksz8081_driver.h
  group thirdparty/cycloneTCP/cyclone_tcp/drivers/g3
    ../../../../../cycloneTCP/cyclone_tcp/drivers/g3/: network_adapter_g3.c network_adapter_g3.h
  group thirdparty/cycloneTCP/cyclone_tcp/drivers/mac
    ../../../../../cycloneTCP/cyclone_tcp/drivers/mac/: same70_eth_driver.c same70_eth_driver.h
  group thirdparty/cycloneTCP/cyclone_tcp/dns_sd
    ../../../../../cycloneTCP/cyclone_tcp/dns_sd/: dns_sd.c dns_sd.h
  group thirdparty/cycloneTCP/cyclone_tcp/dhcpv6
    ../../../../../cycloneTCP/cyclone_tcp/dhcpv6/: dhcpv6_client.h dhcpv6_common.h
  group thirdparty/cycloneTCP/cyclone_tcp/llmnr
    ../../../../../cycloneTCP/cyclone_tcp/llmnr/: llmnr_responder.h llmnr_client.h llmnr_common.h
  group thirdparty/cycloneTCP/cyclone_tcp/ipv4
    ../../../../../cycloneTCP/cyclone_tcp/ipv4/: arp.h auto_ip.h ipv4_frag.h ipv4_misc.h igmp.h ipv4.h icmp.h ipv4_routing.h
  group thirdparty/cycloneTCP/cyclone_tcp/netbios
    ../../../../../cycloneTCP/cyclone_tcp/netbios/: nbns_common.h nbns_responder.h nbns_client.h
  group thirdparty/cycloneTCP/cyclone_tcp/dhcp
    ../../../../../cycloneTCP/cyclone_tcp/dhcp/: dhcp_common.h dhcp_client.h dhcp_server.h
  group thirdparty/cycloneTCP/cyclone_crypto/encoding
    ../../../../../cycloneTCP/cyclone_crypto/encoding/: oid.c asn1.c asn1.h oid.h
  group thirdparty/cycloneTCP/cyclone_crypto/core
    ../../../../../cycloneTCP/cyclone_crypto/core/: crypto.h crypto_legacy.h
  group thirdparty/cycloneTCP/cyclone_crypto/mpi
    ../../../../../cycloneTCP/cyclone_crypto/mpi/: mpi.h
  group thirdparty/cycloneTCP/common
    ../../../../../cycloneTCP/common/: date_time.c debug.c str.c cpu_endian.c os_port_none.c path.c compiler_port.h date_time.h os_port_none.h os_port.h cpu_endian.h fs_port.h path.h debug.h str.h error.h
  group thirdparty/cycloneTCP/atpl_extension
    ../../../../../cycloneTCP/atpl_extension/: async_ping.c async_ping.h
  group thirdparty/cycloneTCP/module_config
    ../../../../../cycloneTCP/module_config/: fs_port_config.h crypto_config.h net_config.h os_port_config.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../freertos/freertos-7.3.0/source/: tasks.c timers.c FreeRTOS_CLI.c list.c queue.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f
    ../../../../../freertos/freertos-7.3.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../freertos/freertos-7.3.0/source/include/: task.h portable.h projdefs.h queue.h FreeRTOS_CLI.h StackMacros.h semphr.h mpu_wrappers.h timers.h list.h FreeRTOS.h croutine.h
  group thirdparty/mbed-tls/library
    ../../../../../mbed-tls/library/: aesni.c cipher.c error.c ccm.c cipher_wrap.c debug_tls.c platform.c version.c aes_tls.c memory_buffer_alloc.c cmac.c timing.c oid_tls.c version_features.c gcm.c platform_util.c cipher_wrap.h common.h aesni.h
  group thirdparty/mbed-tls/sam_aes_alt
    ../../../../../mbed-tls/sam_aes_alt/: aes_alt.c aes_alt.h
  group thirdparty/mbed-tls/include/mbedtls
    ../../../../../mbed-tls/include/mbedtls/: ctr_drbg.h pk.h cipher.h entropy.h timing.h error.h build_info.h compat-2.x.h ccm.h cmac.h md.h oid.h base64.h asn1.h mbedtls_config.h bignum.h platform.h platform_time.h ecp.h platform_util.h memory_buffer_alloc.h gcm.h version.h aes.h sha256.h threading.h debug.h private_access.h check_config.h ssl.h ssl_ciphersuites.h
  group sam/services/plc/buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/usb_wrp
    ../../../../../../sam/services/plc/usb_wrp/: usb_wrp.c usb_wrp.h
  group sam/services/plc/pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/pplc_if/atpl360
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c pplc_if.h
  group sam/services/plc/usi
    ../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/plc/busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/drivers/matrix
    ../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/drivers/xdmac
    ../../../../../../sam/drivers/xdmac/: xdmac.c xdmac.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/rstc
    ../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/trng
    ../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/wdt
    ../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/mpu
    ../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/usbhs
    ../../../../../../sam/drivers/usbhs/: usbhs_device.c usbhs_device.h usbhs_otg.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/afec
    ../../../../../../sam/drivers/afec/: afec.c afec.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/aes
    ../../../../../../sam/drivers/aes/: aes.c aes.h
  group sam/drivers/aes/example
    ../../../../../../sam/drivers/aes/example/: aes_example.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../sam/utils/cmsis/same70/include/: same70q19b.h same70q20b.h same70j20.h same70j19.h same70n21.h same70n19.h same70j20b.h same70n20b.h same70.h same70q20.h same70q21b.h same70n19b.h same70n20.h same70j21.h same70n21b.h same70j19b.h same70q21.h same70q19.h same70j21b.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../sam/utils/cmsis/same70/include/pio/: same70q20b.h same70q21.h same70n20b.h same70q19.h same70n19.h same70j21b.h same70n20.h same70n19b.h same70j19.h same70j21.h same70q20.h same70q21b.h same70n21b.h same70j20b.h same70j19b.h same70n21.h same70q19b.h same70j20.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../sam/utils/cmsis/same70/include/component/: afec.h xdmac.h uart.h chipid.h supc.h pwm.h hsmci.h rtc.h aes.h acc.h gpbr.h wdt.h matrix.h twihs.h utmi.h usbhs.h icm.h tc.h rstc.h qspi.h pmc.h sdramc.h gmac.h ssc.h rswdt.h smc.h rtt.h efc.h dacc.h pio.h usart.h i2sc.h isi.h spi.h trng.h mcan.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../sam/utils/cmsis/same70/include/instance/: matrix.h hsmci.h chipid.h icm.h gpbr.h uart4.h aes.h acc.h rswdt.h uart2.h wdt.h afec0.h uart0.h dacc.h usart1.h pioc.h pioe.h rtc.h trng.h tc3.h pioa.h tc1.h twihs1.h pwm0.h mcan1.h xdmac.h supc.h pmc.h i2sc0.h gmac.h isi.h usbhs.h rtt.h afec1.h spi1.h piob.h uart1.h piod.h smc.h rstc.h qspi.h utmi.h spi0.h sdramc.h efc.h uart3.h usart0.h usart2.h tc2.h pwm1.h twihs2.h tc0.h twihs0.h ssc.h i2sc1.h mcan0.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h mrepeat.h tpaste.h stringz.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/boards/same70_xplained
    ../../../../../../sam/boards/same70_xplained/: init.c same70_xplained.h led.h
  group common/components/plc/atpl360_g3_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_boot.c atpl360_hal_spi.c atpl360.c atpl360.h atpl360_exception.h atpl360_boot.h atpl360_hal_spi.h
  group common/components/plc/atpl360_g3_mac_rt/mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c atpl360_comm.h
  group common/utils
    ../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_udc
    ../../../../../../common/utils/stdio/stdio_udc/: stdio_udc.h
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/usb
    ../../../../../../common/services/usb/: usb_protocol.h usb_atmel.h
  group common/services/usb/udc
    ../../../../../../common/services/usb/udc/: udc.c udc_desc.h udd.h udc.h udi.h
  group common/services/usb/class/cdc
    ../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h sysclk.h pll.h genclk.h
  group common/services/clock/same70
    ../../../../../../common/services/clock/same70/: sysclk.c pll.h sysclk.h genclk.h osc.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
