# Keil uVision project apps_adp_mac_serialized_app_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAM4C16C:CM4 P0 Atmel
  pack: Keil.SAM4_DFP.1.4.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x01000000,0x100000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: apps_template_app
  c flags: Optim=3 oTime=1 uC99=1 wLevel=2
  c define: __G3_STACK__ __FREERTOS__ BOARD=ATPL250AMB ARM_MATH_CM4=true __SAM4C16C_0__
  c misc: --diag_suppress=66
  c include: ..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\routing_wrapper\source;..\..\..\..\..\..\sam\services\plc\pcrc;..\..\..\..\adp\include;..\..\..\..\..\..\common\services\ioport;..\..\..;..\..;..\..\..\..\..\freertos\freertos-7.3.0\source\include;..\..\..\..\..\..\sam\utils;..\..\..\..\routing_loadng\source;..\..\..\..\routing_wrapper\include;..\..\..\..\..\..\common\boards;..\..\..\..\mac_rt\include;..\..\..\..\bootstrap_wrapper\source;..\..\..\..\..\..\sam\drivers\aes;..\..\..\..\..\mbed-tls\sam_aes_alt;..\..\..\..\..\..\sam\drivers\pdc;..\..\..\..\..\..\sam\services\flash_efc;..\..\..\..\..\..\sam\boards;..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\..\..\sam\drivers\uart;..\..\..\..\..\..\sam\services\plc\buart_if;..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam;..\..\..\..\..\..\sam\drivers\adc;..\..\..\..\..\..\sam\drivers\pmc;..\..\..\..\..\..\sam\services\plc\pplc_if\atpl250_multiband;..\..\..\..\..\..\sam\utils\cmsis\sam4c\include;..\..\..\..\routing_loadng\include;..\..\..\..\..\..\sam\drivers\gpbr;..\..\..\..\addons\serial_if_adp_mac;..\..\..\..\pal\atpl250_g3mac\include;..\..\..\..\..\..\common\utils;..\..\..\..\mac_rt\source;..\..\..\..\..\..\sam\boards\atpl250amb;..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\bootstrap_lbp\source;..\..\..\..\..\mbed-tls\library;..\..\..\..\phy\atpl250\include_multiband;..\..\..\..\common\source;..\..\..\..\..\..\sam\drivers\supc;..\..\..\..\mac\include;..\..\..\..\phy\atpl250\addons\sniffer_if;..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\sam\drivers\pio;..\..\..\..\oss;..;..\..\..\..\phy\atpl250\module_config;..\..\..\..\..\..\sam\drivers\trng;..\..\..\..\bootstrap_wrapper\include;..\..\..\..\..\..\sam\services\plc\usi;..\..\..\..\..\..\sam\utils\cmsis\sam4c\source\templates;..\..\..\..\..\..\common\services\gpio;..\..\..\..\common\include;..\..\..\..\coordinator\include;..\..\..\..\..\..\sam\utils\header_files;..\..\..\..;..\..\..\..\..\..\common\services\serial\sam_uart;..\..\..\..\..\..\common\services\clock;..\..\..\..\..\..\sam\services\plc\busart_if;..\..\..\..\coordinator\source;..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\..\sam\services\plc\at45db32;..\..\..\..\bootstrap_lbp\include;..\..\..\..\mac_wrapper\include;..\..\..\..\..\..\common\services\sleepmgr;..\..\..\..\..\mbed-tls\include;..\..\..\..\..\..\sam\drivers\usart;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x1000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\sam4c16c.sct
  group Startup
    ./: startup_SAM4C.s retarget.c system_sam4c.c
  group thirdparty_g3_libs_keil
    ../../../../libs/keil/: lib-g3-keil-loadng.lib lib-g3-keil-mac.lib lib-g3-keil-adp.lib
  group thirdparty_g3_common_source
    ../../../../common/source/: Logger.c Timer.c Random.c Byte.c QueueMng.c
  group thirdparty_g3_phy_atpl250_source_multiband
    ../../../../phy/atpl250/source_multiband/: atpl250_mod_demod.c atpl250_ber.c atpl250_modulator.S atpl250_sampling_error_estimation_as.S atpl250.c atpl250_channel_estimation.c atpl250_reed_solomon.c atpl250_hw_init.c atpl250_jump_ram.c atpl250_txrx_chain.c atpl250_aux_func_as.S atpl250_demodulator.S atpl250_carrier_mapping.c atpl250_sampling_error_estimation.c atpl250_channel_estimation_as.S atpl250_fch.c
  group thirdparty_g3_phy_atpl250_addons_sniffer_if
    ../../../../phy/atpl250/addons/sniffer_if/: sniffer_if.c
  group thirdparty_g3_crypto
    ../../../../crypto/: aes_wrapper.c eax.c cipher_wrapper.c
  group thirdparty_g3_bootstrap_lbp_source
    ../../../../bootstrap_lbp/source/: ProcessLbp.c ProtoEapPsk.c ProtoLbp.c
  group thirdparty_g3_coordinator_source
    ../../../../coordinator/source/: bs_functions.c bs_main.c
  group thirdparty_g3_addons_serial_if_adp_mac
    ../../../../addons/serial_if_adp_mac/: serial_if_common.c serial_if_mac.c serial_if_adp.c serial_if_coordinator.c serial_if_mib_common.c
  group thirdparty_g3_hal_SAM
    ../../../../hal/SAM/: hal.c
  group thirdparty_g3_mac_rt_source
    ../../../../mac_rt/source/: MacRtMib.c MacRtConstants.c MacRt.c
  group thirdparty_g3_pal_atpl250_g3mac_source
    ../../../../pal/atpl250_g3mac/source/: pal.c
  group thirdparty_g3_apps_adp_mac_serialized_app
    ../../: main.c
  group thirdparty_g3_oss
    ../../../../oss/: oss_if.c
  group thirdparty_g3_bootstrap_wrapper_source
    ../../../../bootstrap_wrapper/source/: BootstrapWrapper.c
  group thirdparty_g3_adp
    ../../../../adp/: AdpConf.c
  group thirdparty_g3_routing_wrapper_source
    ../../../../routing_wrapper/source/: RoutingWrapper.c
  group thirdparty_g3_storage
    ../../../../storage/: storage.c
  group thirdparty_g3_mac_wrapper_source
    ../../../../mac_wrapper/source/: mac_wrapper.c
  group mbed-tls_library
    ../../../../../mbed-tls/library/: memory_buffer_alloc.c aesni.c cipher.c error.c ccm.c cipher_wrap.c debug_tls.c platform.c version.c aes_tls.c cmac.c timing.c oid_tls.c version_features.c gcm.c platform_util.c
  group mbed-tls_sam_aes_alt
    ../../../../../mbed-tls/sam_aes_alt/: aes_alt.c
  group sam_services_plc_buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c
  group sam_services_plc_pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c
  group sam_services_plc_usi
    ../../../../../../sam/services/plc/usi/: usi.c
  group sam_services_plc_busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c
  group sam_services_plc_pplc_if_atpl250_multiband
    ../../../../../../sam/services/plc/pplc_if/atpl250_multiband/: pplc_if.c
  group sam_services_plc_at45db32
    ../../../../../../sam/services/plc/at45db32/: at45db32.c
  group sam_services_flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c
  group sam_drivers_pdc
    ../../../../../../sam/drivers/pdc/: pdc.c
  group sam_drivers_tc
    ../../../../../../sam/drivers/tc/: tc.c
  group sam_drivers_uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam_drivers_trng
    ../../../../../../sam/drivers/trng/: trng.c
  group sam_drivers_adc
    ../../../../../../sam/drivers/adc/: adc.c adc_sam3u.c
  group sam_drivers_efc
    ../../../../../../sam/drivers/efc/: efc.c
  group sam_drivers_supc
    ../../../../../../sam/drivers/supc/: supc.c
  group sam_drivers_pmc
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam_drivers_usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam_drivers_pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam_drivers_spi
    ../../../../../../sam/drivers/spi/: spi.c
  group sam_drivers_gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c
  group sam_drivers_aes
    ../../../../../../sam/drivers/aes/: aes.c
  group sam_boards_atpl250amb
    ../../../../../../sam/boards/atpl250amb/: init.c
  group common_utils_stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common_utils_interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common_services_clock_sam4c
    ../../../../../../common/services/clock/sam4c/: sysclk.c
  group common_services_sleepmgr_sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group common_services_serial
    ../../../../../../common/services/serial/: usart_serial.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
