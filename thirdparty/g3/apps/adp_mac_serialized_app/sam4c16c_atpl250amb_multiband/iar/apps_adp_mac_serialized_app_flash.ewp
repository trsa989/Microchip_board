# IAR project apps_adp_mac_serialized_app_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4C16C_0 Atmel ATSAM4C16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __G3_STACK__; __FREERTOS__; BOARD=ATPL250AMB; ARM_MATH_CM4=true; __SAM4C16C_0__
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\routing_wrapper\source; ..\..\..\..\..\..\sam\services\plc\pcrc; ..\..\..\..\adp\include; ..\..\..\..\..\..\common\services\ioport; ..\..\..; ..\..; ..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\..\..\sam\utils; ..\..\..\..\routing_loadng\source; ..\..\..\..\routing_wrapper\include; ..\..\..\..\..\..\common\boards; ..\..\..\..\mac_rt\include; ..\..\..\..\bootstrap_wrapper\source; ..\..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\mbed-tls\sam_aes_alt; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\sam\services\plc\buart_if; ..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam; ..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\..\sam\services\plc\pplc_if\atpl250_multiband; ..\..\..\..\..\..\sam\utils\cmsis\sam4c\include; ..\..\..\..\routing_loadng\include; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\addons\serial_if_adp_mac; ..\..\..\..\pal\atpl250_g3mac\include; ..\..\..\..\..\..\common\utils; ..\..\..\..\mac_rt\source; ..\..\..\..\..\..\sam\boards\atpl250amb; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\bootstrap_lbp\source; ..\..\..\..\..\mbed-tls\library; ..\..\..\..\phy\atpl250\include_multiband; ..\..\..\..\common\source; ..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\mac\include; ..\..\..\..\phy\atpl250\addons\sniffer_if; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\oss; ..; ..\..\..\..\phy\atpl250\module_config; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\bootstrap_wrapper\include; ..\..\..\..\..\..\sam\services\plc\usi; ..\..\..\..\..\..\sam\utils\cmsis\sam4c\source\templates; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\common\include; ..\..\..\..\coordinator\include; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..; ..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\services\plc\busart_if; ..\..\..\..\coordinator\source; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\services\plc\at45db32; ..\..\..\..\bootstrap_lbp\include; ..\..\..\..\mac_wrapper\include; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\mbed-tls\include; ..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_adp_mac_serialized_app_flash.bin
  ILINK.IlinkOutputFile: apps_adp_mac_serialized_app_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\sam\utils\linker_scripts\sam4c\iar\sam4c16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/g3/libs/iar
    ../../../../libs/iar/: lib-g3-iar-loadng.a lib-g3-iar-mac.a lib-g3-iar-adp.a
  group thirdparty/g3/common/source
    ../../../../common/source/: Logger.c Timer.c Random.c Byte.c QueueMng.c
  group thirdparty/g3/common/include
    ../../../../common/include/: Byte.h Logger.h QueueMng.h Random.h g3_stack_version.h Timer.h
  group thirdparty/g3/phy/atpl250/source_multiband
    ../../../../phy/atpl250/source_multiband/: atpl250_mod_demod.c atpl250_ber.c atpl250_modulator.S atpl250_sampling_error_estimation_as.S atpl250.c atpl250_channel_estimation.c atpl250_reed_solomon.c atpl250_hw_init.c atpl250_jump_ram.c atpl250_txrx_chain.c atpl250_aux_func_as.S atpl250_demodulator.S atpl250_carrier_mapping.c atpl250_sampling_error_estimation.c atpl250_channel_estimation_as.S atpl250_fch.c
  group thirdparty/g3/phy/atpl250/addons/sniffer_if
    ../../../../phy/atpl250/addons/sniffer_if/: sniffer_if.c sniffer_if.h
  group thirdparty/g3/phy/atpl250/include_multiband
    ../../../../phy/atpl250/include_multiband/: atpl250_sampling_error_estimation.h atpl250_ber.h atpl250_reed_solomon.h atpl250_reg.h atpl250_common.h atpl250_fch.h atpl250_version.h atpl250_carrier_mapping.h atpl250_hw_init.h atpl250_mod_demod.h atpl250_jump_ram.h atpl250.h atpl250_channel_and_sfo_estimation_params.h atpl250_txrx_chain.h atpl250_channel_estimation.h
  group thirdparty/g3/phy/atpl250/module_config
    ../../../../phy/atpl250/module_config/: conf_fw.h conf_hw.h
  group thirdparty/g3/crypto
    ../../../../crypto/: aes_wrapper.c eax.c cipher_wrapper.c brg_types.h aes_wrapper.h cipher_wrapper.h eax.h mode_hdr.h brg_endian.h
  group thirdparty/g3/bootstrap_lbp/source
    ../../../../bootstrap_lbp/source/: ProcessLbp.c ProtoEapPsk.c ProtoLbp.c ProtoLbpVersion.h
  group thirdparty/g3/bootstrap_lbp/include
    ../../../../bootstrap_lbp/include/: ProtoLbp.h ProcessLbp.h ProtoEapPsk.h
  group thirdparty/g3/coordinator/source
    ../../../../coordinator/source/: bs_functions.c bs_main.c bs_functions.h
  group thirdparty/g3/coordinator/include
    ../../../../coordinator/include/: bs_api.h
  group thirdparty/g3/addons/serial_if_adp_mac
    ../../../../addons/serial_if_adp_mac/: serial_if_common.c serial_if_mac.c serial_if_adp.c serial_if_coordinator.c serial_if_mib_common.c serial_if_common.h serial_if_mac.h serial_if_adp.h serial_if_coordinator.h serial_if_mib_common.h
  group thirdparty/g3/hal
    ../../../../hal/: hal.h
  group thirdparty/g3/hal/SAM
    ../../../../hal/SAM/: hal.c hal.h
  group thirdparty/g3/mac_rt/source
    ../../../../mac_rt/source/: MacRtMib.c MacRtConstants.c MacRt.c MacRtVersion.h MacPhyInterface.h
  group thirdparty/g3/mac_rt/include
    ../../../../mac_rt/include/: MacRtConstants.h MacRtMib.h MacRtDefs.h MacRt.h
  group thirdparty/g3/pal/atpl250_g3mac/source
    ../../../../pal/atpl250_g3mac/source/: pal.c
  group thirdparty/g3/pal/atpl250_g3mac/include
    ../../../../pal/atpl250_g3mac/include/: pal.h
  group thirdparty/g3/apps
    ../../../: conf_global.h
  group thirdparty/g3/apps/adp_mac_serialized_app
    ../../: main.c
  group thirdparty/g3/apps/adp_mac_serialized_app/sam4c16c_atpl250amb_multiband
    ../: conf_tables.h conf_sleepmgr.h conf_oss.h conf_project.h conf_clock.h conf_busart_if.h conf_buart_if.h conf_pplc_if.h conf_board.h FreeRTOSConfig.h conf_bs.h conf_hal.h conf_uart_serial.h conf_usi.h
  group thirdparty/g3/apps/adp_mac_serialized_app/sam4c16c_atpl250amb_multiband/iar
    ./: asf.h
  group thirdparty/g3/oss
    ../../../../oss/: oss_if.c oss_if.h
  group thirdparty/g3/bootstrap_wrapper/source
    ../../../../bootstrap_wrapper/source/: BootstrapWrapper.c
  group thirdparty/g3/bootstrap_wrapper/include
    ../../../../bootstrap_wrapper/include/: BootstrapWrapper.h
  group thirdparty/g3/adp
    ../../../../adp/: AdpConf.c
  group thirdparty/g3/adp/include
    ../../../../adp/include/: AdpApiTypes.h AdpSharedTypes.h AdpApi.h
  group thirdparty/g3/routing_wrapper/source
    ../../../../routing_wrapper/source/: RoutingWrapper.c
  group thirdparty/g3/routing_wrapper/include
    ../../../../routing_wrapper/include/: RoutingApi.h RoutingTypes.h
  group thirdparty/g3/storage
    ../../../../storage/: storage.c storage.h
  group thirdparty/g3/mac_wrapper/source
    ../../../../mac_wrapper/source/: mac_wrapper.c
  group thirdparty/g3/mac_wrapper/include
    ../../../../mac_wrapper/include/: mac_wrapper_defs.h mac_wrapper.h
  group thirdparty/g3/mac/include
    ../../../../mac/include/: MacApi.h MacDefs.h MacMib.h
  group thirdparty/g3/routing_loadng/include
    ../../../../routing_loadng/include/: ProtoLoadNg.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../freertos/freertos-7.3.0/source/: tasks.c timers.c FreeRTOS_CLI.c list.c queue.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam
    ../../../../../freertos/freertos-7.3.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../freertos/freertos-7.3.0/source/include/: portable.h projdefs.h croutine.h FreeRTOS.h mpu_wrappers.h FreeRTOS_CLI.h timers.h StackMacros.h list.h queue.h task.h semphr.h
  group thirdparty/mbed-tls/library
    ../../../../../mbed-tls/library/: memory_buffer_alloc.c aesni.c cipher.c error.c ccm.c cipher_wrap.c debug_tls.c platform.c version.c aes_tls.c cmac.c timing.c oid_tls.c version_features.c gcm.c platform_util.c aesni.h cipher_wrap.h common.h
  group thirdparty/mbed-tls/sam_aes_alt
    ../../../../../mbed-tls/sam_aes_alt/: aes_alt.c aes_alt.h
  group thirdparty/mbed-tls/include/mbedtls
    ../../../../../mbed-tls/include/mbedtls/: cipher.h pk.h entropy.h memory_buffer_alloc.h gcm.h md.h oid.h timing.h ctr_drbg.h cmac.h base64.h error.h aes.h asn1.h ssl_ciphersuites.h build_info.h bignum.h debug.h private_access.h compat-2.x.h mbedtls_config.h threading.h platform_time.h check_config.h ssl.h sha256.h version.h ccm.h platform.h ecp.h platform_util.h
  group sam/services/plc/buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/usi
    ../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/plc/busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/plc/pplc_if/atpl250_multiband
    ../../../../../../sam/services/plc/pplc_if/atpl250_multiband/: pplc_if.c pplc_if.h
  group sam/services/plc/at45db32
    ../../../../../../sam/services/plc/at45db32/: at45db32.c at45db32.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4c/source/templates
    ../../../../../../sam/utils/cmsis/sam4c/source/templates/: system_sam4c.c
  group sam/utils/cmsis/sam4c/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4c/source/templates/iar/: startup_sam4c.c
  group sam/utils/cmsis/sam4c/include
    ../../../../../../sam/utils/cmsis/sam4c/include/: sam4c8c_1.h sam4c32c_1.h sam4c.h sam4c4c_0.h sam4c32e_1.h sam4c4c_1.h sam4c32c_0.h system_sam4c.h sam4c32e_0.h sam4c16c_1.h sam4c8c_0.h sam4c16c_0.h
  group sam/utils/cmsis/sam4c/include/component
    ../../../../../../sam/utils/cmsis/sam4c/include/component/: component_tc.h component_spi.h component_chipid.h component_ipc.h component_smc.h component_supc.h component_trng.h component_rtt.h component_uotghs.h component_twi.h component_slcdc.h component_pio.h component_usart.h component_gpbr.h component_cmcc.h component_adc.h component_rtc.h component_matrix.h component_wdt.h component_pwm.h component_rswdt.h component_pdc.h component_rstc.h component_uart.h component_icm.h component_pmc.h component_aes.h component_efc.h
  group sam/utils/cmsis/sam4c/include/instance
    ../../../../../../sam/utils/cmsis/sam4c/include/instance/: instance_ipc1.h instance_efc.h instance_pioc.h instance_slcdc.h instance_rtc.h instance_twi0.h instance_matrix1.h instance_uart1.h instance_piod.h instance_twi1.h instance_chipid.h instance_ipc0.h instance_trng.h instance_gpbr.h instance_piob.h instance_pwm.h instance_uart0.h instance_smc0.h instance_tc0.h instance_rstc.h instance_spi0.h instance_cmcc1.h instance_supc.h instance_pmc.h instance_adc.h instance_rswdt.h instance_efc1.h instance_usart0.h instance_usart2.h instance_usart4.h instance_rtt.h instance_wdt.h instance_icm.h instance_cmcc0.h instance_uotghs.h instance_tc1.h instance_aes.h instance_efc0.h instance_matrix0.h instance_spi1.h instance_usart1.h instance_usart3.h instance_smc1.h instance_pioa.h
  group sam/utils/cmsis/sam4c/include/pio
    ../../../../../../sam/utils/cmsis/sam4c/include/pio/: pio_sam4c32e.h pio_sam4c4c.h pio_sam4c16c.h pio_sam4c32c.h pio_sam4c8c.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h stringz.h preprocessor.h tpaste.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/trng
    ../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/adc
    ../../../../../../sam/drivers/adc/: adc.c adc_sam3u.c adc.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/aes
    ../../../../../../sam/drivers/aes/: aes.c aes.h
  group sam/drivers/aes/example
    ../../../../../../sam/drivers/aes/example/: aes_example.h
  group sam/boards/atpl250amb
    ../../../../../../sam/boards/atpl250amb/: init.c led.h atpl250amb.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: pll.h osc.h sysclk.h genclk.h
  group common/services/clock/sam4c
    ../../../../../../common/services/clock/sam4c/: sysclk.c osc.h pll.h sysclk.h genclk.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
