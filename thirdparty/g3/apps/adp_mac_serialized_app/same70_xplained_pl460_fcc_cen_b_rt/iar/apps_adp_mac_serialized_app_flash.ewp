# IAR project apps_adp_mac_serialized_app_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21 Atmel ATSAME70Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __G3_STACK__; UDD_ENABLE; ARM_MATH_CM7=true; BOARD=SAME70_XPLAINED; __SAME70Q21B__; __FREERTOS__
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\routing_wrapper\source; ..\..\..\..\..\..\sam\services\plc\pcrc; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\sam\services\plc\buart_if; ..\..\..\..\..\mbed-tls\include; ..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt; ..\..\..\..\..\..\common\services\ioport; ..; ..\..; ..\..\..\..\..\..\common\services\usb\class\cdc\device; ..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\common\services\usb; ..\..\..\..\routing_loadng\source; ..\..\..\..\..\..\sam\services\plc\usb_wrp; ..\..\..\..\phy\atpl360\coup_tx_config\coup_params; ..\..\..\..\mac_rt\include; ..\..\..\..\..\..\sam\utils\cmsis\same70\include; ..\..\..\..\bootstrap_wrapper\source; ..\..\..\..\..\..\sam\drivers\wdt; ..\..\..\..\..\..\common\services\usb\udc; ..\..\..\..\..\mbed-tls\sam_aes_alt; ..\..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\..\sam\boards; ..\..\..\..\adp\include; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\sam\drivers\afec; ..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\sam\boards\same70_xplained; ..\..\..\..\routing_loadng\include; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\addons\serial_if_adp_mac; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\common\services\usb\class\cdc; ..\..\..; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\common\boards; ..\..\..\..\bootstrap_lbp\source; ..\..\..\..\..\mbed-tls\library; ..\..\..\..\common\source; ..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\mac\include; ..\..\..\..\..\..\sam\drivers\mpu; ..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\sam\services\plc\busart_if; ..\..\..\..\oss; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\usbhs; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\bootstrap_wrapper\include; ..\..\..\..\common\include; ..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f; ..\..\..\..\..\..\sam\services\plc\usi; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt; ..\..\..\..\..\..\sam\drivers\matrix; ..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460_fcc_cen_b; ..\..\..\..\phy\atpl360\coup_tx_config; ..\..\..\..; ..\..\..\..\pal\atpl360_g3macrt\include; ..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\routing_wrapper\include; ..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360; ..\..\..\..\..\..\sam\utils\cmsis\same70\source\templates; ..\..\..\..\coordinator\source; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\bootstrap_lbp\include; ..\..\..\..\..\..\sam\drivers\xdmac; ..\..\..\..\mac_wrapper\include; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\common\utils\stdio\stdio_udc; ..\..\..\..\coordinator\include; ..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_adp_mac_serialized_app_flash.bin
  ILINK.IlinkOutputFile: apps_adp_mac_serialized_app_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\sam\utils\linker_scripts\same70\same70q21\iar\flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_G3_MAC_RT_CENB.bin,atpl_bin_cenb,P_atpl_bin_cenb,8; --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_G3_MAC_RT_FCC.bin,atpl_bin_fcc,P_atpl_bin_fcc,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/g3/libs/iar
    ../../../../libs/iar/: lib-g3-iar-loadng.a lib-g3-iar-mac.a lib-g3-iar-adp.a
  group thirdparty/g3/crypto
    ../../../../crypto/: aes_wrapper.c eax.c cipher_wrapper.c brg_types.h cipher_wrapper.h eax.h aes_wrapper.h mode_hdr.h brg_endian.h
  group thirdparty/g3/bootstrap_lbp/source
    ../../../../bootstrap_lbp/source/: ProcessLbp.c ProtoEapPsk.c ProtoLbp.c ProtoLbpVersion.h
  group thirdparty/g3/bootstrap_lbp/include
    ../../../../bootstrap_lbp/include/: ProtoLbp.h ProcessLbp.h ProtoEapPsk.h
  group thirdparty/g3/coordinator/source
    ../../../../coordinator/source/: bs_functions.c bs_main.c bs_functions.h
  group thirdparty/g3/coordinator/include
    ../../../../coordinator/include/: bs_api.h
  group thirdparty/g3/addons/serial_if_adp_mac
    ../../../../addons/serial_if_adp_mac/: serial_if_common.c serial_if_mac.c serial_if_adp.c serial_if_coordinator.c serial_if_mib_common.c serial_if_common.h serial_if_mac.h serial_if_adp.h serial_if_coordinator.h serial_if_mib_common.h
  group thirdparty/g3/common/source
    ../../../../common/source/: Byte.c Logger.c Timer.c Random.c QueueMng.c
  group thirdparty/g3/common/include
    ../../../../common/include/: Byte.h QueueMng.h Logger.h g3_stack_version.h Timer.h Random.h
  group thirdparty/g3/oss
    ../../../../oss/: oss_if.c oss_if.h
  group thirdparty/g3/phy/atpl360/coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c coup_tx_config.h coup_defs.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_params
    ../../../../phy/atpl360/coup_tx_config/coup_params/: pl460_1_5b_fcc.h pl460_sb_fcc.h pl460_plcoup014_cen_b.h plcoup014_cen_b.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt
    ../../../../phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt/: coup_pl360_wrp.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_conf/pl460_fcc_cen_b
    ../../../../phy/atpl360/coup_tx_config/coup_conf/pl460_fcc_cen_b/: coup_conf.h
  group thirdparty/g3/hal
    ../../../../hal/: hal.h
  group thirdparty/g3/hal/SAM_atpl360
    ../../../../hal/SAM_atpl360/: hal.c hal.h
  group thirdparty/g3/pal/atpl360_g3macrt/source
    ../../../../pal/atpl360_g3macrt/source/: pal.c
  group thirdparty/g3/pal/atpl360_g3macrt/include
    ../../../../pal/atpl360_g3macrt/include/: pal.h
  group thirdparty/g3/apps
    ../../../: conf_global.h
  group thirdparty/g3/apps/adp_mac_serialized_app
    ../../: main.c
  group thirdparty/g3/apps/adp_mac_serialized_app/same70_xplained_pl460_fcc_cen_b_rt
    ../: conf_tables.h conf_usi.h conf_oss.h conf_project.h conf_clock.h conf_busart_if.h conf_buart_if.h conf_usb.h conf_sleepmgr.h conf_pplc_if.h conf_board.h FreeRTOSConfig.h conf_bs.h conf_hal.h conf_atpl360.h conf_uart_serial.h
  group thirdparty/g3/apps/adp_mac_serialized_app/same70_xplained_pl460_fcc_cen_b_rt/iar
    ./: asf.h
  group thirdparty/g3/adp
    ../../../../adp/: AdpConf.c
  group thirdparty/g3/adp/include
    ../../../../adp/include/: AdpApiTypes.h AdpSharedTypes.h AdpApi.h
  group thirdparty/g3/routing_wrapper/source
    ../../../../routing_wrapper/source/: RoutingWrapper.c
  group thirdparty/g3/routing_wrapper/include
    ../../../../routing_wrapper/include/: RoutingApi.h RoutingTypes.h
  group thirdparty/g3/storage
    ../../../../storage/: storage.c storage.h
  group thirdparty/g3/bootstrap_wrapper/source
    ../../../../bootstrap_wrapper/source/: BootstrapWrapper.c
  group thirdparty/g3/bootstrap_wrapper/include
    ../../../../bootstrap_wrapper/include/: BootstrapWrapper.h
  group thirdparty/g3/mac_wrapper/source
    ../../../../mac_wrapper/source/: mac_wrapper.c
  group thirdparty/g3/mac_wrapper/include
    ../../../../mac_wrapper/include/: mac_wrapper_defs.h mac_wrapper.h
  group thirdparty/g3/mac/include
    ../../../../mac/include/: MacApi.h MacDefs.h MacMib.h
  group thirdparty/g3/mac_rt/include
    ../../../../mac_rt/include/: MacRtConstants.h MacRtMib.h MacRtDefs.h MacRt.h
  group thirdparty/g3/routing_loadng/include
    ../../../../routing_loadng/include/: ProtoLoadNg.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../freertos/freertos-7.3.0/source/: tasks.c timers.c FreeRTOS_CLI.c list.c queue.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f
    ../../../../../freertos/freertos-7.3.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../freertos/freertos-7.3.0/source/include/: task.h portable.h projdefs.h FreeRTOS.h FreeRTOS_CLI.h croutine.h mpu_wrappers.h timers.h StackMacros.h list.h queue.h semphr.h
  group thirdparty/mbed-tls/library
    ../../../../../mbed-tls/library/: cipher.c aesni.c error.c ccm.c memory_buffer_alloc.c cipher_wrap.c debug_tls.c platform.c version.c aes_tls.c cmac.c timing.c oid_tls.c version_features.c gcm.c platform_util.c aesni.h cipher_wrap.h common.h
  group thirdparty/mbed-tls/sam_aes_alt
    ../../../../../mbed-tls/sam_aes_alt/: aes_alt.c aes_alt.h
  group thirdparty/mbed-tls/include/mbedtls
    ../../../../../mbed-tls/include/mbedtls/: version.h cmac.h cipher.h memory_buffer_alloc.h build_info.h entropy.h md.h oid.h timing.h ctr_drbg.h pk.h error.h aes.h ssl_ciphersuites.h bignum.h threading.h base64.h debug.h private_access.h compat-2.x.h mbedtls_config.h platform_time.h check_config.h asn1.h ecp.h ssl.h sha256.h gcm.h ccm.h platform.h platform_util.h
  group sam/services/plc/buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/usb_wrp
    ../../../../../../sam/services/plc/usb_wrp/: usb_wrp.c usb_wrp.h
  group sam/services/plc/pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/pplc_if/atpl360
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c pplc_if.h
  group sam/services/plc/usi
    ../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/plc/busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/drivers/matrix
    ../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/drivers/xdmac
    ../../../../../../sam/drivers/xdmac/: xdmac.c xdmac.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/trng
    ../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/wdt
    ../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/mpu
    ../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/usbhs
    ../../../../../../sam/drivers/usbhs/: usbhs_device.c usbhs_otg.h usbhs_device.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/afec
    ../../../../../../sam/drivers/afec/: afec.c afec.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/aes
    ../../../../../../sam/drivers/aes/: aes.c aes.h
  group sam/drivers/aes/example
    ../../../../../../sam/drivers/aes/example/: aes_example.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../sam/utils/cmsis/same70/include/: same70j19.h same70q20b.h same70n20b.h same70q19b.h same70n19.h same70j20.h same70q21.h same70.h same70n21.h same70q19.h same70q20.h same70j21b.h same70j21.h same70j19b.h same70n21b.h same70q21b.h same70j20b.h same70n19b.h same70n20.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../sam/utils/cmsis/same70/include/pio/: same70q20b.h same70j19.h same70n20.h same70j21.h same70n20b.h same70q21b.h same70n21.h same70q20.h same70n19.h same70n19b.h same70q19.h same70q19b.h same70j19b.h same70q21.h same70n21b.h same70j20.h same70j21b.h same70j20b.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../sam/utils/cmsis/same70/include/component/: aes.h afec.h rswdt.h efc.h wdt.h sdramc.h rtc.h xdmac.h uart.h acc.h pio.h gpbr.h qspi.h tc.h utmi.h usart.h dacc.h pmc.h rstc.h chipid.h twihs.h rtt.h i2sc.h ssc.h gmac.h usbhs.h supc.h hsmci.h pwm.h smc.h isi.h matrix.h spi.h icm.h trng.h mcan.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../sam/utils/cmsis/same70/include/instance/: utmi.h afec0.h rtc.h dacc.h usart1.h gpbr.h pioc.h pioe.h sdramc.h gmac.h trng.h uart3.h i2sc0.h matrix.h tc3.h pioa.h isi.h usart0.h tc1.h usart2.h twihs2.h qspi.h twihs1.h usbhs.h tc2.h acc.h hsmci.h spi0.h pwm1.h chipid.h smc.h uart1.h pwm0.h tc0.h rtt.h uart4.h aes.h twihs0.h efc.h mcan1.h icm.h afec1.h spi1.h ssc.h xdmac.h rswdt.h mcan0.h i2sc1.h piob.h uart2.h supc.h piod.h rstc.h wdt.h uart0.h pmc.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/boards/same70_xplained
    ../../../../../../sam/boards/same70_xplained/: init.c same70_xplained.h led.h
  group common/components/plc/atpl360_g3_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_boot.c atpl360_hal_spi.c atpl360.c atpl360_boot.h atpl360.h atpl360_hal_spi.h atpl360_exception.h
  group common/components/plc/atpl360_g3_mac_rt/mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c atpl360_comm.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_udc
    ../../../../../../common/utils/stdio/stdio_udc/: stdio_udc.h
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/usb
    ../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/udc
    ../../../../../../common/services/usb/udc/: udc.c udc.h udi.h udc_desc.h udd.h
  group common/services/usb/class/cdc
    ../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/same70
    ../../../../../../common/services/clock/same70/: sysclk.c pll.h sysclk.h genclk.h osc.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
