# IAR project apps_adp_mac_serialized_app_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21 Atmel ATSAME70Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __G3_STACK__; UDD_ENABLE; ARM_MATH_CM7=true; __SAME70Q21__; BOARD=ATPL250ABN_V2; __FREERTOS__
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\routing_wrapper\source; ..\..\..\..\..\..\sam\services\plc\pcrc; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\sam\services\plc\buart_if; ..\..\..\..\..\..\common\services\ioport; ..\..\..; ..\..; ..\..\..\..\..\..\common\services\usb\class\cdc\device; ..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\common\services\usb; ..\..\..\..\routing_loadng\source; ..\..\..\..\..\..\sam\services\plc\usb_wrp; ..\..\..\..\..\..\sam\drivers\mpu; ..\..\..\..\mac_rt\include; ..\..\..\..\..\..\sam\utils\cmsis\same70\include; ..\..\..\..\bootstrap_wrapper\source; ..\..\..\..\..\..\sam\drivers\wdt; ..\..\..\..\..\..\common\services\usb\udc; ..\..\..\..\..\mbed-tls\sam_aes_alt; ..\..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\..\sam\boards; ..\..\..\..\adp\include; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\sam\drivers\afec; ..\..\..\..\..\..\sam\boards\atpl250abn_v2; ..; ..\..\..\..\..\..\sam\drivers\sdramc; ..\..\..\..\..\..\sam\services\plc\pplc_if\atpl250_multiband; ..\..\..\..\routing_loadng\include; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\addons\serial_if_adp_mac; ..\..\..\..\pal\atpl250_g3mac\include; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\usb\class\cdc; ..\..\..\..\mac_rt\source; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\bootstrap_lbp\source; ..\..\..\..\..\mbed-tls\library; ..\..\..\..\phy\atpl250\include_multiband; ..\..\..\..\common\source; ..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\mac\include; ..\..\..\..\phy\atpl250\addons\sniffer_if; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\oss; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\usbhs; ..\..\..\..\phy\atpl250\module_config; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\bootstrap_wrapper\include; ..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f; ..\..\..\..\..\..\sam\services\plc\usi; ..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\common\include; ..\..\..\..\..\..\sam\drivers\matrix; ..\..\..\..\coordinator\include; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..; ..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\routing_wrapper\include; ..\..\..\..\..\..\sam\services\plc\busart_if; ..\..\..\..\..\..\sam\utils\cmsis\same70\source\templates; ..\..\..\..\coordinator\source; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\bootstrap_lbp\include; ..\..\..\..\..\..\sam\drivers\xdmac; ..\..\..\..\mac_wrapper\include; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\common\utils\stdio\stdio_udc; ..\..\..\..\..\mbed-tls\include; ..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_adp_mac_serialized_app_flash.bin
  ILINK.IlinkOutputFile: apps_adp_mac_serialized_app_flash.out
  ILINK.IlinkIcfFile: ..\..\linker_scripts\iar\same70q21_atpl250abn_v2_flash_tcm_fcc.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/g3/libs/iar
    ../../../../libs/iar/: lib-g3-iar-loadng.a lib-g3-iar-mac.a lib-g3-iar-adp.a
  group thirdparty/g3/common/source
    ../../../../common/source/: Logger.c Byte.c Timer.c Random.c QueueMng.c
  group thirdparty/g3/common/include
    ../../../../common/include/: QueueMng.h Logger.h g3_stack_version.h Timer.h Random.h Byte.h
  group thirdparty/g3/phy/atpl250/source_multiband
    ../../../../phy/atpl250/source_multiband/: atpl250_mod_demod.c atpl250_ber.c atpl250_modulator.S atpl250_sampling_error_estimation_as.S atpl250.c atpl250_channel_estimation.c atpl250_reed_solomon.c atpl250_hw_init.c atpl250_jump_ram.c atpl250_fch.c atpl250_txrx_chain.c atpl250_aux_func_as.S atpl250_demodulator.S atpl250_carrier_mapping.c atpl250_sampling_error_estimation.c atpl250_channel_estimation_as.S
  group thirdparty/g3/phy/atpl250/addons/sniffer_if
    ../../../../phy/atpl250/addons/sniffer_if/: sniffer_if.c sniffer_if.h
  group thirdparty/g3/phy/atpl250/module_config
    ../../../../phy/atpl250/module_config/: conf_fw.h conf_hw.h
  group thirdparty/g3/phy/atpl250/include_multiband
    ../../../../phy/atpl250/include_multiband/: atpl250_sampling_error_estimation.h atpl250_ber.h atpl250_channel_and_sfo_estimation_params.h atpl250_reed_solomon.h atpl250_channel_estimation.h atpl250_jump_ram.h atpl250_fch.h atpl250_version.h atpl250.h atpl250_reg.h atpl250_common.h atpl250_carrier_mapping.h atpl250_hw_init.h atpl250_mod_demod.h atpl250_txrx_chain.h
  group thirdparty/g3/crypto
    ../../../../crypto/: aes_wrapper.c eax.c cipher_wrapper.c brg_types.h cipher_wrapper.h eax.h aes_wrapper.h brg_endian.h mode_hdr.h
  group thirdparty/g3/bootstrap_lbp/source
    ../../../../bootstrap_lbp/source/: ProcessLbp.c ProtoEapPsk.c ProtoLbp.c ProtoLbpVersion.h
  group thirdparty/g3/bootstrap_lbp/include
    ../../../../bootstrap_lbp/include/: ProtoLbp.h ProcessLbp.h ProtoEapPsk.h
  group thirdparty/g3/coordinator/source
    ../../../../coordinator/source/: bs_functions.c bs_main.c bs_functions.h
  group thirdparty/g3/coordinator/include
    ../../../../coordinator/include/: bs_api.h
  group thirdparty/g3/addons/serial_if_adp_mac
    ../../../../addons/serial_if_adp_mac/: serial_if_common.c serial_if_mac.c serial_if_adp.c serial_if_coordinator.c serial_if_mib_common.c serial_if_common.h serial_if_mac.h serial_if_adp.h serial_if_coordinator.h serial_if_mib_common.h
  group thirdparty/g3/mac_rt/source
    ../../../../mac_rt/source/: MacRtMib.c MacRtConstants.c MacRt.c MacRtVersion.h MacPhyInterface.h
  group thirdparty/g3/mac_rt/include
    ../../../../mac_rt/include/: MacRtConstants.h MacRtMib.h MacRtDefs.h MacRt.h
  group thirdparty/g3/oss
    ../../../../oss/: oss_if.c oss_if.h
  group thirdparty/g3/pal/atpl250_g3mac/source
    ../../../../pal/atpl250_g3mac/source/: pal.c
  group thirdparty/g3/pal/atpl250_g3mac/include
    ../../../../pal/atpl250_g3mac/include/: pal.h
  group thirdparty/g3/apps
    ../../../: conf_global.h
  group thirdparty/g3/apps/adp_mac_serialized_app
    ../../: main.c
  group thirdparty/g3/apps/adp_mac_serialized_app/same70q21_atpl250abn_multiband
    ../: conf_tables.h conf_usi.h conf_project.h conf_clock.h conf_busart_if.h conf_buart_if.h conf_board.h conf_usb.h conf_sleepmgr.h conf_pplc_if.h conf_uart_serial.h FreeRTOSConfig.h conf_bs.h conf_oss.h conf_hal.h
  group thirdparty/g3/apps/adp_mac_serialized_app/same70q21_atpl250abn_multiband/iar
    ./: asf.h
  group thirdparty/g3/adp
    ../../../../adp/: AdpConf.c
  group thirdparty/g3/adp/include
    ../../../../adp/include/: AdpApiTypes.h AdpSharedTypes.h AdpApi.h
  group thirdparty/g3/routing_wrapper/source
    ../../../../routing_wrapper/source/: RoutingWrapper.c
  group thirdparty/g3/routing_wrapper/include
    ../../../../routing_wrapper/include/: RoutingApi.h RoutingTypes.h
  group thirdparty/g3/storage
    ../../../../storage/: storage.c storage.h
  group thirdparty/g3/bootstrap_wrapper/source
    ../../../../bootstrap_wrapper/source/: BootstrapWrapper.c
  group thirdparty/g3/bootstrap_wrapper/include
    ../../../../bootstrap_wrapper/include/: BootstrapWrapper.h
  group thirdparty/g3/mac_wrapper/source
    ../../../../mac_wrapper/source/: mac_wrapper.c
  group thirdparty/g3/mac_wrapper/include
    ../../../../mac_wrapper/include/: mac_wrapper_defs.h mac_wrapper.h
  group thirdparty/g3/hal
    ../../../../hal/: hal.h
  group thirdparty/g3/hal/SAM
    ../../../../hal/SAM/: hal.c hal.h
  group thirdparty/g3/mac/include
    ../../../../mac/include/: MacApi.h MacDefs.h MacMib.h
  group thirdparty/g3/routing_loadng/include
    ../../../../routing_loadng/include/: ProtoLoadNg.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../freertos/freertos-7.3.0/source/: tasks.c timers.c FreeRTOS_CLI.c list.c queue.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f
    ../../../../../freertos/freertos-7.3.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../freertos/freertos-7.3.0/source/include/: task.h portable.h queue.h FreeRTOS.h FreeRTOS_CLI.h mpu_wrappers.h projdefs.h croutine.h timers.h StackMacros.h list.h semphr.h
  group thirdparty/mbed-tls/library
    ../../../../../mbed-tls/library/: memory_buffer_alloc.c cipher.c error.c ccm.c cipher_wrap.c debug_tls.c platform.c version.c aes_tls.c cmac.c timing.c aesni.c oid_tls.c version_features.c gcm.c platform_util.c cipher_wrap.h common.h aesni.h
  group thirdparty/mbed-tls/sam_aes_alt
    ../../../../../mbed-tls/sam_aes_alt/: aes_alt.c aes_alt.h
  group thirdparty/mbed-tls/include/mbedtls
    ../../../../../mbed-tls/include/mbedtls/: version.h cmac.h pk.h base64.h entropy.h cipher.h memory_buffer_alloc.h build_info.h md.h oid.h timing.h ctr_drbg.h error.h aes.h ssl_ciphersuites.h bignum.h threading.h debug.h private_access.h compat-2.x.h mbedtls_config.h platform_time.h check_config.h asn1.h ssl.h sha256.h gcm.h ccm.h platform.h ecp.h platform_util.h
  group sam/services/plc/buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/usb_wrp
    ../../../../../../sam/services/plc/usb_wrp/: usb_wrp.c usb_wrp.h
  group sam/services/plc/pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/usi
    ../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/plc/busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/plc/pplc_if/atpl250_multiband
    ../../../../../../sam/services/plc/pplc_if/atpl250_multiband/: pplc_if.c pplc_if.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/drivers/matrix
    ../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/drivers/xdmac
    ../../../../../../sam/drivers/xdmac/: xdmac.c xdmac.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/trng
    ../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/wdt
    ../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/mpu
    ../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/usbhs
    ../../../../../../sam/drivers/usbhs/: usbhs_device.c usbhs_otg.h usbhs_device.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/sdramc
    ../../../../../../sam/drivers/sdramc/: sdramc.c sdramc.h
  group sam/drivers/afec
    ../../../../../../sam/drivers/afec/: afec.c afec.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/aes
    ../../../../../../sam/drivers/aes/: aes.c aes.h
  group sam/drivers/aes/example
    ../../../../../../sam/drivers/aes/example/: aes_example.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../sam/utils/cmsis/same70/include/: same70j19.h same70q20b.h same70n20b.h same70q19b.h same70n19.h same70j20.h same70q21.h same70.h same70n21.h same70q19.h same70q20.h same70j21b.h same70j21.h same70j19b.h same70n21b.h same70q21b.h same70j20b.h same70n19b.h same70n20.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../sam/utils/cmsis/same70/include/pio/: same70q20b.h same70n20.h same70q21.h same70n19b.h same70j19.h same70j21.h same70n20b.h same70q21b.h same70n21.h same70q20.h same70n19.h same70q19.h same70q19b.h same70j19b.h same70n21b.h same70j20.h same70j21b.h same70j20b.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../sam/utils/cmsis/same70/include/component/: aes.h afec.h rswdt.h efc.h wdt.h sdramc.h rtc.h xdmac.h uart.h acc.h pio.h gpbr.h qspi.h tc.h utmi.h usart.h dacc.h pmc.h rstc.h chipid.h twihs.h rtt.h i2sc.h ssc.h gmac.h usbhs.h supc.h hsmci.h pwm.h smc.h isi.h matrix.h spi.h icm.h trng.h mcan.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../sam/utils/cmsis/same70/include/instance/: utmi.h mcan0.h rtc.h dacc.h usart1.h gpbr.h pioc.h i2sc0.h pioe.h smc.h sdramc.h gmac.h trng.h matrix.h tc3.h pioa.h uart3.h isi.h usart0.h tc1.h usart2.h mcan1.h supc.h twihs1.h usbhs.h tc2.h acc.h hsmci.h spi0.h pwm1.h chipid.h twihs2.h uart1.h pwm0.h tc0.h icm.h rtt.h uart4.h aes.h twihs0.h efc.h afec1.h qspi.h spi1.h ssc.h xdmac.h rswdt.h i2sc1.h piob.h uart2.h piod.h rstc.h wdt.h afec0.h uart0.h pmc.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h mrepeat.h stringz.h tpaste.h
  group sam/boards/atpl250abn_v2
    ../../../../../../sam/boards/atpl250abn_v2/: init.c low_level_init.c atpl250abn_v2.h led.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_udc
    ../../../../../../common/utils/stdio/stdio_udc/: stdio_udc.h
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/usb
    ../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/udc
    ../../../../../../common/services/usb/udc/: udc.c udc_desc.h udc.h udd.h udi.h
  group common/services/usb/class/cdc
    ../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/same70
    ../../../../../../common/services/clock/same70/: sysclk.c pll.h osc.h genclk.h sysclk.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
