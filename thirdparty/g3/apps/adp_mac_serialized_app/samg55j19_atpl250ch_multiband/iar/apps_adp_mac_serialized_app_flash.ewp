# IAR project apps_adp_mac_serialized_app_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __G3_STACK__; __FREERTOS__; BOARD=ATPL250CH; __SAMG55J19__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\routing_wrapper\source; ..\..\..\..\..\..\sam\services\plc\pcrc; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\adp\include; ..\..\..\..\mac\include; ..\..\..\..\..\..\common\services\ioport; ..\..\..; ..\..; ..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\include; ..\..\..\..\..\..\sam\utils; ..\..\..\..\routing_loadng\source; ..\..\..\..\routing_wrapper\include; ..\..\..\..\..\..\common\boards; ..\..\..\..\mac_rt\include; ..\..\..\..\bootstrap_wrapper\source; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\services\plc\buart_if; ..\..\..\..\common\source; ..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\..\sam\boards\atpl250ch; ..\..\..\..\..\..\sam\services\plc\pplc_if\atpl250_multiband; ..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\source\templates; ..\..\..\..\routing_loadng\include; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\addons\serial_if_adp_mac; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\bootstrap_lbp\source; ..\..\..\..\..\mbed-tls\library; ..\..\..\..\phy\atpl250\include_multiband; ..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\phy\atpl250\addons\sniffer_if; ..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\mac_rt\source; ..\..\..\..\oss; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\phy\atpl250\module_config; ..\..\..\..\bootstrap_wrapper\include; ..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f; ..\..\..\..\..\..\sam\services\plc\usi; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\common\include; ..\..\..\..\coordinator\include; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..; ..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\sam\services\plc\busart_if; ..\..\..\..\coordinator\source; ..\..\..\..\pal\atpl250_g3mac\include; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\bootstrap_lbp\include; ..\..\..\..\mac_wrapper\include; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\mbed-tls\include; ..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_adp_mac_serialized_app_flash.bin
  ILINK.IlinkOutputFile: apps_adp_mac_serialized_app_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\sam\utils\linker_scripts\samg\samg55j19\iar\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/g3/libs/iar
    ../../../../libs/iar/: lib-g3-iar-loadng.a lib-g3-iar-mac.a lib-g3-iar-adp.a
  group thirdparty/g3/common/source
    ../../../../common/source/: Logger.c Byte.c Timer.c Random.c QueueMng.c
  group thirdparty/g3/common/include
    ../../../../common/include/: Byte.h Logger.h QueueMng.h Random.h g3_stack_version.h Timer.h
  group thirdparty/g3/phy/atpl250/source_multiband
    ../../../../phy/atpl250/source_multiband/: atpl250_mod_demod.c atpl250_ber.c atpl250_modulator.S atpl250_sampling_error_estimation_as.S atpl250.c atpl250_channel_estimation.c atpl250_reed_solomon.c atpl250_hw_init.c atpl250_jump_ram.c atpl250_txrx_chain.c atpl250_aux_func_as.S atpl250_demodulator.S atpl250_carrier_mapping.c atpl250_sampling_error_estimation.c atpl250_channel_estimation_as.S atpl250_fch.c
  group thirdparty/g3/phy/atpl250/addons/sniffer_if
    ../../../../phy/atpl250/addons/sniffer_if/: sniffer_if.c sniffer_if.h
  group thirdparty/g3/phy/atpl250/include_multiband
    ../../../../phy/atpl250/include_multiband/: atpl250_sampling_error_estimation.h atpl250_channel_estimation.h atpl250_jump_ram.h atpl250_fch.h atpl250_version.h atpl250_reg.h atpl250_ber.h atpl250_common.h atpl250_carrier_mapping.h atpl250_hw_init.h atpl250_mod_demod.h atpl250_reed_solomon.h atpl250.h atpl250_channel_and_sfo_estimation_params.h atpl250_txrx_chain.h
  group thirdparty/g3/phy/atpl250/module_config
    ../../../../phy/atpl250/module_config/: conf_fw.h conf_hw.h
  group thirdparty/g3/crypto
    ../../../../crypto/: aes_wrapper.c eax.c cipher_wrapper.c brg_types.h aes_wrapper.h cipher_wrapper.h eax.h mode_hdr.h brg_endian.h
  group thirdparty/g3/bootstrap_lbp/source
    ../../../../bootstrap_lbp/source/: ProcessLbp.c ProtoEapPsk.c ProtoLbp.c ProtoLbpVersion.h
  group thirdparty/g3/bootstrap_lbp/include
    ../../../../bootstrap_lbp/include/: ProtoLbp.h ProcessLbp.h ProtoEapPsk.h
  group thirdparty/g3/coordinator/source
    ../../../../coordinator/source/: bs_functions.c bs_main.c bs_functions.h
  group thirdparty/g3/coordinator/include
    ../../../../coordinator/include/: bs_api.h
  group thirdparty/g3/addons/serial_if_adp_mac
    ../../../../addons/serial_if_adp_mac/: serial_if_common.c serial_if_mac.c serial_if_adp.c serial_if_coordinator.c serial_if_mib_common.c serial_if_common.h serial_if_mac.h serial_if_adp.h serial_if_coordinator.h serial_if_mib_common.h
  group thirdparty/g3/mac_rt/source
    ../../../../mac_rt/source/: MacRtMib.c MacRtConstants.c MacRt.c MacRtVersion.h MacPhyInterface.h
  group thirdparty/g3/mac_rt/include
    ../../../../mac_rt/include/: MacRtDefs.h MacRtConstants.h MacRtMib.h MacRt.h
  group thirdparty/g3/pal/atpl250_g3mac/source
    ../../../../pal/atpl250_g3mac/source/: pal.c
  group thirdparty/g3/pal/atpl250_g3mac/include
    ../../../../pal/atpl250_g3mac/include/: pal.h
  group thirdparty/g3/apps
    ../../../: conf_global.h
  group thirdparty/g3/apps/adp_mac_serialized_app
    ../../: main.c
  group thirdparty/g3/apps/adp_mac_serialized_app/samg55j19_atpl250ch_multiband
    ../: conf_project.h conf_sleepmgr.h conf_oss.h conf_clock.h conf_busart_if.h conf_tables.h conf_usb.h conf_buart_if.h conf_usi.h conf_pplc_if.h FreeRTOSConfig.h conf_board.h conf_bs.h conf_hal.h conf_uart_serial.h
  group thirdparty/g3/apps/adp_mac_serialized_app/samg55j19_atpl250ch_multiband/iar
    ./: asf.h
  group thirdparty/g3/oss
    ../../../../oss/: oss_if.c oss_if.h
  group thirdparty/g3/adp
    ../../../../adp/: AdpConf.c
  group thirdparty/g3/adp/include
    ../../../../adp/include/: AdpApiTypes.h AdpSharedTypes.h AdpApi.h
  group thirdparty/g3/routing_wrapper/source
    ../../../../routing_wrapper/source/: RoutingWrapper.c
  group thirdparty/g3/routing_wrapper/include
    ../../../../routing_wrapper/include/: RoutingApi.h RoutingTypes.h
  group thirdparty/g3/storage
    ../../../../storage/: storage.c storage.h
  group thirdparty/g3/bootstrap_wrapper/source
    ../../../../bootstrap_wrapper/source/: BootstrapWrapper.c
  group thirdparty/g3/bootstrap_wrapper/include
    ../../../../bootstrap_wrapper/include/: BootstrapWrapper.h
  group thirdparty/g3/mac_wrapper/source
    ../../../../mac_wrapper/source/: mac_wrapper.c
  group thirdparty/g3/mac_wrapper/include
    ../../../../mac_wrapper/include/: mac_wrapper_defs.h mac_wrapper.h
  group thirdparty/g3/hal
    ../../../../hal/: hal.h
  group thirdparty/g3/hal/SAM
    ../../../../hal/SAM/: hal.c hal.h
  group thirdparty/g3/mac/include
    ../../../../mac/include/: MacApi.h MacDefs.h MacMib.h
  group thirdparty/g3/routing_loadng/include
    ../../../../routing_loadng/include/: ProtoLoadNg.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../freertos/freertos-7.3.0/source/: tasks.c timers.c FreeRTOS_CLI.c list.c queue.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f
    ../../../../../freertos/freertos-7.3.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../freertos/freertos-7.3.0/source/include/: portable.h projdefs.h FreeRTOS.h queue.h task.h croutine.h mpu_wrappers.h FreeRTOS_CLI.h timers.h StackMacros.h list.h semphr.h
  group thirdparty/mbed-tls/library
    ../../../../../mbed-tls/library/: memory_buffer_alloc.c aesni.c cipher.c error.c ccm.c cipher_wrap.c debug_tls.c platform.c version.c aes_tls.c cmac.c timing.c oid_tls.c version_features.c gcm.c platform_util.c cipher_wrap.h common.h aesni.h
  group thirdparty/mbed-tls/include/mbedtls
    ../../../../../mbed-tls/include/mbedtls/: cmac.h cipher.h pk.h entropy.h memory_buffer_alloc.h version.h build_info.h gcm.h md.h oid.h timing.h ctr_drbg.h base64.h error.h aes.h asn1.h bignum.h threading.h debug.h private_access.h compat-2.x.h mbedtls_config.h platform_time.h check_config.h ssl.h sha256.h ssl_ciphersuites.h ccm.h platform.h ecp.h platform_util.h
  group sam/services/plc/buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/usi
    ../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/plc/busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/plc/pplc_if/atpl250_multiband
    ../../../../../../sam/services/plc/pplc_if/atpl250_multiband/: pplc_if.c pplc_if.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/adc
    ../../../../../../sam/drivers/adc/: adc2.c adc2.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../../sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../../sam/utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../../sam/utils/cmsis/samg/samg55/include/: samg55j18.h samg55g19.h samg55.h system_samg55.h samg55j19.h samg55n19.h samg55g18.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../../sam/utils/cmsis/samg/samg55/include/pio/: samg55g19.h samg55n19.h samg55j19.h samg55g18.h samg55j18.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../../sam/utils/cmsis/samg/samg55/include/instance/: pmc.h pdmic1.h usart2.h crccu.h twi3.h usart0.h twi5.h udp.h usart7.h wdt.h cmcc.h twi7.h uhp.h supc.h usart5.h flexcom1.h spi7.h usart3.h i2sc0.h piob.h efc.h spi5.h flexcom7.h rtt.h mem2mem.h matrix.h tc0.h rstc.h twi1.h spi1.h spi3.h twi6.h i2sc1.h flexcom6.h chipid.h flexcom0.h spi4.h flexcom3.h tc1.h flexcom4.h twi2.h spi6.h twi0.h spi0.h pdmic0.h flexcom5.h pioa.h adc.h rtc.h spi2.h usart6.h usart1.h usart4.h gpbr.h flexcom2.h twi4.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../../sam/utils/cmsis/samg/samg55/include/component/: uhp.h pmc.h supc.h pio.h matrix.h flexcom.h rtc.h adc.h rstc.h i2sc.h efc.h crccu.h pdmic.h pdc.h mem2mem.h udp.h gpbr.h usart.h spi.h rtt.h chipid.h cmcc.h twi.h tc.h wdt.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/boards/atpl250ch
    ../../../../../../sam/boards/atpl250ch/: init.c atpl250ch.h led.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/samg
    ../../../../../../common/services/clock/samg/: sysclk.c osc.h pll.h genclk.h sysclk.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
