# Keil uVision project apps_adp_mac_serialized_app_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.0
  cpu: IROM(0x00400000,0x00200000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: apps_template_app
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: __G3_STACK__ UDD_ENABLE ARM_MATH_CM7=true BOARD=SAME70_XPLAINED __SAME70Q21B__ __FREERTOS__
  c misc: --diag_suppress=66 --gnu
  c include: ..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\routing_wrapper\source;..\..\..\..\..\..\sam\services\plc\pcrc;..\..\..\..\..\..\sam\utils\fpu;..\..\..\..\..\..\sam\services\plc\buart_if;..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt;..\..\..\..\..\..\common\services\ioport;..\..\..;..\..;..\..\..\..\..\..\common\services\usb\class\cdc\device;..\..\..\..\..\freertos\freertos-7.3.0\source\include;..\..\..\..\..\..\sam\utils;..\..\..\..\..\..\common\services\usb;..\..\..\..\routing_loadng\source;..\..\..\..\..\..\sam\services\plc\usb_wrp;..\..\..\..\phy\atpl360\coup_tx_config\coup_params;..\..\..\..\mac_rt\include;..\..\..\..\..\..\sam\utils\cmsis\same70\include;..\..\..\..\bootstrap_wrapper\source;..\..\..\..\..\..\sam\drivers\wdt;..\..\..\..\..\..\common\services\usb\udc;..\..\..\..\..\mbed-tls\sam_aes_alt;..\..\..\..\..\..\sam\drivers\aes;..\..\..\..\..\..\sam\boards;..\..\..\..\adp\include;..\..\..\..\..\..\sam\drivers\uart;..\..\..\..\..\..\sam\drivers\afec;..\..\..\..\..\..\sam\drivers\pmc;..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\..\..\sam\boards\same70_xplained;..;..\..\..\..\routing_loadng\include;..\..\..\..\..\..\sam\drivers\gpbr;..\..\..\..\addons\serial_if_adp_mac;..\..\..\..\..\..\common\utils;..\..\..\..\..\..\common\services\delay;..\..\..\..\..\..\common\services\usb\class\cdc;..\..\..\..\..\..\sam\drivers\pio;..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\..\..\common\boards;..\..\..\..\bootstrap_lbp\source;..\..\..\..\..\mbed-tls\library;..\..\..\..\common\source;..\..\..\..\..\..\sam\drivers\mpu;..\..\..\..\mac\include;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt;..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\sam\drivers\supc;..\..\..\..\..\..\sam\services\plc\busart_if;..\..\..\..\oss;..\..\..\..\..\..\common\services\clock;..\..\..\..\..\..\sam\drivers\usbhs;..\..\..\..\..\..\sam\drivers\trng;..\..\..\..\bootstrap_wrapper\include;..\..\..\..\common\include;..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f;..\..\..\..\..\..\sam\services\plc\usi;..\..\..\..\..\..\sam\drivers\matrix;..\..\..\..\..\..\common\services\gpio;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt;..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460_fcc_cen_a;..\..\..\..\coordinator\include;..\..\..\..\phy\atpl360\coup_tx_config;..\..\..\..;..\..\..\..\pal\atpl360_g3macrt\include;..\..\..\..\..\..\common\services\serial\sam_uart;..\..\..\..\..\..\sam\utils\header_files;..\..\..\..\routing_wrapper\include;..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360;..\..\..\..\..\..\sam\utils\cmsis\same70\source\templates;..\..\..\..\coordinator\source;..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\..\sam\services\flash_efc;..\..\..\..\bootstrap_lbp\include;..\..\..\..\..\..\sam\drivers\xdmac;..\..\..\..\mac_wrapper\include;..\..\..\..\..\..\common\services\sleepmgr;..\..\..\..\..\..\common\utils\stdio\stdio_udc;..\..\..\..\..\mbed-tls\include;..\..\..\..\..\..\sam\drivers\usart;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: sram.sct
  link misc: --diag_suppress=L6314
target flash (ARM-ADS)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.0
  cpu: as above
  output: uart
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAME70_XPLD __SAME70Q21__ flash TRACE_LEVEL=4
  c include: ..\..\;..\..\..\..\libraries\libchip;..\..\..\..\libraries\libchip\include;..\..\..\..\libraries\libchip\include\same70;..\..\..\..\libraries\libchip\include\cmsis\CMSIS\Include;..\..\..\..\libraries\libboard;..\..\..\..\libraries\libboard\include
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: flash.sct
  link misc: --diag_suppress=L6314
  group added to the first target's files
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360.c atpl360_boot.c atpl360_hal_spi.c
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c
    ../../../../../../common/services/clock/same70/: sysclk.c
    ../../../../../../common/services/delay/sam/: cycle_counter.c
    ../../../../../../common/services/serial/: usart_serial.c
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
    ../../../../../../common/services/usb/udc/: udc.c
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
    ../../../../../../common/utils/stdio/: read.c write.c
    ../../../../../../sam/boards/same70_xplained/: init.c
    ../../../../../../sam/drivers/aes/: aes.c
    ../../../../../../sam/drivers/afec/: afec.c
    ../../../../../../sam/drivers/efc/: efc.c
    ../../../../../../sam/drivers/gpbr/: gpbr.c
    ../../../../../../sam/drivers/matrix/: matrix.c
    ../../../../../../sam/drivers/mpu/: mpu.c
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c
    ../../../../../../sam/drivers/spi/: spi.c
    ../../../../../../sam/drivers/supc/: supc.c
    ../../../../../../sam/drivers/tc/: tc.c
    ../../../../../../sam/drivers/trng/: trng.c
    ../../../../../../sam/drivers/uart/: uart.c
    ../../../../../../sam/drivers/usart/: usart.c
    ../../../../../../sam/drivers/usbhs/: usbhs_device.c
    ../../../../../../sam/drivers/wdt/: wdt.c
    ../../../../../../sam/drivers/xdmac/: xdmac.c
    ../../../../../../sam/services/flash_efc/: flash_efc.c
    ../../../../../../sam/services/plc/buart_if/: buart_if.c
    ../../../../../../sam/services/plc/busart_if/: busart_if.c
    ../../../../../../sam/services/plc/pcrc/: pcrc.c
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c
    ../../../../../../sam/services/plc/usb_wrp/: usb_wrp.c
    ../../../../../../sam/services/plc/usi/: usi.c
    ../../../../../mbed-tls/library/: aes_tls.c aesni.c ccm.c cipher.c cipher_wrap.c cmac.c debug_tls.c error.c gcm.c memory_buffer_alloc.c oid_tls.c platform.c platform_util.c timing.c version.c version_features.c
    ../../../../../mbed-tls/sam_aes_alt/: aes_alt.c
    ../../../../addons/serial_if_adp_mac/: serial_if_adp.c serial_if_common.c serial_if_coordinator.c serial_if_mac.c serial_if_mib_common.c
    ../../../../adp/: AdpConf.c
    ../../../../bootstrap_lbp/source/: ProcessLbp.c ProtoEapPsk.c ProtoLbp.c
    ../../../../bootstrap_wrapper/source/: BootstrapWrapper.c
    ../../../../common/source/: Byte.c Logger.c QueueMng.c Random.c Timer.c
    ../../../../coordinator/source/: bs_functions.c bs_main.c
    ../../../../crypto/: aes_wrapper.c cipher_wrapper.c eax.c
    ../../../../hal/SAM_atpl360/: hal.c
    ../../../../libs/keil/: lib-g3-keil-adp.lib lib-g3-keil-loadng.lib lib-g3-keil-mac.lib
    ../../../../mac_wrapper/source/: mac_wrapper.c
    ../../../../oss/: oss_if.c
    ../../../../pal/atpl360_g3macrt/source/: pal.c
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c
    ../../../../routing_wrapper/source/: RoutingWrapper.c
    ../../../../storage/: storage.c
    ../../: main.c
    ./: atpl_bin_multi.S retarget.c startup_SAME70.s system_same70.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
