# Keil uVision project apps_adp_mac_serialized_app_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAM4CMS16C:CM4_P0 Atmel
  pack: Keil.SAM4_DFP.1.6.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x01000000,0x100000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: apps_template_app
  c flags: Optim=3 oTime=1 uC99=1 wLevel=2
  c define: __G3_STACK__ __FREERTOS__ BOARD=ATPL360MB __SAM4CMS16C_0__ ARM_MATH_CM4=true
  c misc: --diag_suppress=66
  c include: ..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\routing_wrapper\source;..\..\..\..\..\..\sam\services\plc\pcrc;..\..\..\..\..\..\sam\services\plc\buart_if;..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt;..\..\..\..\..\..\common\services\ioport;..\..\..;..\..;..\..\..\..\..\freertos\freertos-7.3.0\source\include;..\..\..\..\..\..\sam\components\display\c0216CiZ;..\..\..\..\..\..\sam\utils;..\..\..\..\phy\atpl360\coup_tx_config;..\..\..\..\routing_wrapper\include;..\..\..\..\phy\atpl360\coup_tx_config\coup_params;..\..\..\..\mac_rt\include;..\..\..\..\bootstrap_wrapper\source;..\..\..\..\..\..\sam\drivers\aes;..\..\..\..\..\mbed-tls\sam_aes_alt;..\..\..\..\..\..\sam\drivers\pdc;..\..\..\..\common\include;..\..\..\..\..\..\sam\boards;..\..\..\..\mac\include;..\..\..\..\..\..\sam\drivers\uart;..\..\..\..\adp\include;..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam;..\..\..\..\..\..\sam\drivers\adc;..\..\..\..\..\..\sam\drivers\pmc;..\..\..\..\..\..\sam\boards\atpl360mb;..\..\..\..\..\..\common\services\twi;..\..\..\..\routing_loadng\include;..\..\..\..\..\..\sam\drivers\gpbr;..\..\..\..\addons\serial_if_adp_mac;..\..\..\..\..\..\common\utils;..\..\..\..\..\..\common\services\delay;..\..\..\..\pal\atpl360_g3macrt\include;..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\..\..\sam\services\flash_efc;..\..\..\..\bootstrap_lbp\source;..\..\..\..\..\mbed-tls\library;..\..\..\..\common\source;..\..\..\..\..\..\sam\drivers\supc;..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt;..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\sam\drivers\pio;..\..\..\..\..\..\sam\services\plc\busart_if;..\..\..\..\oss;..\..\..\..\..\..\common\services\clock;..\..\..\..\..\..\sam\drivers\trng;..\..\..\..\routing_loadng\source;..\..\..\..\..\..\sam\utils\cmsis\sam4cm\source\templates;..\..\..\..\bootstrap_wrapper\include;..\..\..\..\..\..\sam\services\plc\usi;..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl360_cen_b;..\..\..\..\..\..\common\services\gpio;..\..\..\..\..\..\sam\drivers\twi;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt;..\..\..\..\coordinator\include;..;..\..\..\..;..\..\..\..\..\..\common\services\serial\sam_uart;..\..\..\..\..\..\sam\utils\header_files;..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\sam\utils\cmsis\sam4cm\include;..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360;..\..\..\..\coordinator\source;..\..\..\..\..\..\common\boards;..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\..\sam\services\plc\at45db32;..\..\..\..\bootstrap_lbp\include;..\..\..\..\mac_wrapper\include;..\..\..\..\..\..\common\services\sleepmgr;..\..\..\..\..\mbed-tls\include;..\..\..\..\..\..\sam\drivers\usart;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x1000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\sam4c16c.sct
  group Startup
    ./: startup_SAM4CM.s retarget.c system_sam4cm.c atpl_bin.S
  group thirdparty_g3_libs_keil
    ../../../../libs/keil/: lib-g3-keil-loadng.lib lib-g3-keil-mac.lib lib-g3-keil-adp.lib
  group thirdparty_g3_crypto
    ../../../../crypto/: aes_wrapper.c eax.c cipher_wrapper.c
  group thirdparty_g3_bootstrap_lbp_source
    ../../../../bootstrap_lbp/source/: ProcessLbp.c ProtoEapPsk.c ProtoLbp.c
  group thirdparty_g3_coordinator_source
    ../../../../coordinator/source/: bs_functions.c bs_main.c
  group thirdparty_g3_addons_serial_if_adp_mac
    ../../../../addons/serial_if_adp_mac/: serial_if_common.c serial_if_mac.c serial_if_adp.c serial_if_coordinator.c serial_if_mib_common.c
  group thirdparty_g3_common_source
    ../../../../common/source/: Byte.c Logger.c Timer.c Random.c QueueMng.c
  group thirdparty_g3_phy_atpl360_coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c
  group thirdparty_g3_hal_SAM_atpl360
    ../../../../hal/SAM_atpl360/: hal.c
  group thirdparty_g3_pal_atpl360_g3macrt_source
    ../../../../pal/atpl360_g3macrt/source/: pal.c
  group thirdparty_g3_apps_adp_mac_serialized_app
    ../../: main.c
  group thirdparty_g3_oss
    ../../../../oss/: oss_if.c
  group thirdparty_g3_bootstrap_wrapper_source
    ../../../../bootstrap_wrapper/source/: BootstrapWrapper.c
  group thirdparty_g3_adp
    ../../../../adp/: AdpConf.c
  group thirdparty_g3_routing_wrapper_source
    ../../../../routing_wrapper/source/: RoutingWrapper.c
  group thirdparty_g3_storage
    ../../../../storage/: storage.c
  group thirdparty_g3_mac_wrapper_source
    ../../../../mac_wrapper/source/: mac_wrapper.c
  group mbed-tls_library
    ../../../../../mbed-tls/library/: cipher.c aesni.c error.c ccm.c cipher_wrap.c debug_tls.c platform.c version.c aes_tls.c memory_buffer_alloc.c cmac.c timing.c oid_tls.c version_features.c gcm.c platform_util.c
  group mbed-tls_sam_aes_alt
    ../../../../../mbed-tls/sam_aes_alt/: aes_alt.c
  group sam_services_plc_buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c
  group sam_services_plc_pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c
  group sam_services_plc_pplc_if_atpl360
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c
  group sam_services_plc_usi
    ../../../../../../sam/services/plc/usi/: usi.c
  group sam_services_plc_busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c
  group sam_services_plc_at45db32
    ../../../../../../sam/services/plc/at45db32/: at45db32.c
  group sam_services_flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c
  group sam_drivers_pdc
    ../../../../../../sam/drivers/pdc/: pdc.c
  group sam_drivers_tc
    ../../../../../../sam/drivers/tc/: tc.c
  group sam_drivers_uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam_drivers_trng
    ../../../../../../sam/drivers/trng/: trng.c
  group sam_drivers_adc
    ../../../../../../sam/drivers/adc/: adc.c adc_sam3u.c
  group sam_drivers_efc
    ../../../../../../sam/drivers/efc/: efc.c
  group sam_drivers_supc
    ../../../../../../sam/drivers/supc/: supc.c
  group sam_drivers_pmc
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam_drivers_usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam_drivers_pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam_drivers_twi
    ../../../../../../sam/drivers/twi/: twi.c
  group sam_drivers_spi
    ../../../../../../sam/drivers/spi/: spi.c
  group sam_drivers_gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c
  group sam_drivers_aes
    ../../../../../../sam/drivers/aes/: aes.c
  group sam_components_display_c0216CiZ
    ../../../../../../sam/components/display/c0216CiZ/: c0216CiZ.c
  group sam_boards_atpl360mb
    ../../../../../../sam/boards/atpl360mb/: init.c
  group common_components_plc_atpl360_g3_mac_rt_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c
  group common_components_plc_atpl360_g3_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_boot.c atpl360_hal_spi.c atpl360.c
  group common_utils_stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common_utils_interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common_services_delay_sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c
  group common_services_clock_sam4cm
    ../../../../../../common/services/clock/sam4cm/: sysclk.c
  group common_services_sleepmgr_sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group common_services_serial
    ../../../../../../common/services/serial/: usart_serial.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
