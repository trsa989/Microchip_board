# Keil uVision project apps_adp_mac_serialized_app_flash.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: ATSAMG55J19 Atmel
  pack: Microchip.SAMG_DFP.3.8.197
  cpu: IROM(0x00400000,0x80000) IRAM(0x20000000,0x28000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: apps_template_app +hex
  c flags: Optim=5 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: __G3_STACK__ __SAMG55J19__ UDD_ENABLE BOARD=PL360G55CF_EK G3_HYBRID_PROFILE __FREERTOS__ ARM_MATH_CM4=true
  c misc: -fgnu -Wno-implicit-function-declaration
  c include: ..\..\..\..\routing_wrapper\source;..\..\..\..\..\..\sam\services\plc\usi;..\..\..\..\..\..\common\services\ioport;..\..;..\..\..\..\..\..\common\services\usb\class\cdc\device;..\..\..\..\..\freertos\freertos-7.3.0\source\include;..\..\..\..\..\..\common\services\usb;..\..\..\..\phy\atpl360\coup_tx_config;..\..\..\..\routing_loadng\include;..\..\..\..\..\..\sam\boards;..\..\..\..\..\..\sam\services\plc\buart_if;..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\source\templates;..\..\..\..\..\..\common\utils;..\..\..\..\..\..\sam\drivers\pio;..\..\..\..\pal_rf\rf215_g3mac\include;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_tx_rx;..\..\..\..\..\..\common\components\rf\at86rf215\addons\sniffer_if\g3;..\..\..\..\..\mbed-tls\include;..\..\..\..\..\..\sam\services\plc\usb_wrp;..\..\..\..\coordinator\source;..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\..\sam\services\flash_efc;..\..\..\..\..\..\common\utils\stdio\stdio_udc;..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\coordinator\include;..\..\..\..\..\..\sam\utils;..\..\..\..\routing_loadng\source;..\..\..\..\..\..\sam\drivers\udp;..\..\..\..\mac_rt\include;..\..\..\..\bootstrap_wrapper\source;..\..\..\..\..\..\sam\drivers\pdc;..\..\..\..\common\source;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_pll;..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl360_cen_a_fcc;..\..\..\..\oss;..\..\..\..\..\..\sam\drivers\flexcom;..\..\..\..\bootstrap_wrapper\include;..\..\..\..\..\..\sam\utils\header_files;..\..\..\..;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_bbc;..\..\..\..\..\..\sam\services\plc\busart_if;..\..\..\..\..\..\sam\services\plc\pcrc;..\..\..\..\adp\include;..\..\..;..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\include;..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f;..\..\..\..\routing_wrapper\include;..;..\..\..\..\..\..\sam\drivers\wdt;..\..\..\..\..\..\sam\boards\pl360g55cf_ek;..\..\..\..\..\..\sam\drivers\pmc;..\..\..\..\..\..\common\components\rf\at86rf215\addons;..\..\..\..\addons\serial_if_adp_mac;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_fe;..\..\..\..\mac\include;..\..\..\..\pal\atpl360_g3macrt\include;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt;..\..\..\..\..\..\common\services\gpio;..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\..\..\sam\drivers\matrix;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_common;..\..\..\..\bootstrap_lbp\include;..\..\..\..\..\..\common\services\sleepmgr;..\..\..\..\phy\atpl360\coup_tx_config\coup_params;..\..\..\..\..\..\sam\utils\fpu;..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt;..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\common\boards;..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\..\..\common\services\usb\udc;..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360;..\..\..\..\..\..\sam\drivers\adc;..\..\..\..\hyal\include;..\..\..\..\..\..\sam\drivers\gpbr;..\..\..\..\..\..\common\services\delay;..\..\..\..\..\..\common\services\usb\class\cdc;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_irq;..\..\..\..\bootstrap_lbp\source;..\..\..\..\..\..\common\components\rf\at86rf215;..\..\..\..\..\mbed-tls\library;..\..\..\..\..\..\sam\services\timer_1us;..\..\..\..\..\..\sam\drivers\supc;..\..\..\..\..\..\common\services\clock;..\..\..\..\mac_rf\include;..\..\..\..\common\include;..\..\..\..\..\..\common\services\serial\sam_uart;..\..\..\..\..\..\sam\services\rf\prf_if\at86rf215;..\..\..\..\mac_wrapper\include;..\..\..\..\..\..\sam\drivers\usart;.
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\samg55j19.sct
  group Startup
    ./: startup_SAMG55.s retarget.c system_samg55.c atpl_bin_multi.S
  group thirdparty_g3_libs_keil
    ../../../../libs/keil/: lib-g3-keil-mac.lib lib-g3-keil-loadng-hyb.lib lib-g3-keil-mac-rf.lib lib-g3-keil-adp-hyb.lib
  group thirdparty_g3_pal_rf_rf215_g3mac_source
    ../../../../pal_rf/rf215_g3mac/source/: pal_rf.c
  group thirdparty_g3_crypto
    ../../../../crypto/: aes_wrapper.c eax.c cipher_wrapper.c
  group thirdparty_g3_bootstrap_lbp_source
    ../../../../bootstrap_lbp/source/: ProcessLbp.c ProtoEapPsk.c ProtoLbp.c
  group thirdparty_g3_coordinator_source
    ../../../../coordinator/source/: bs_functions.c bs_main.c
  group thirdparty_g3_addons_serial_if_adp_mac
    ../../../../addons/serial_if_adp_mac/: serial_if_common.c serial_if_mac.c serial_if_adp.c serial_if_coordinator.c serial_if_mib_common.c
  group thirdparty_g3_common_source
    ../../../../common/source/: Byte.c Logger.c Timer.c Random.c QueueMng.c
  group thirdparty_g3_oss
    ../../../../oss/: oss_if.c
  group thirdparty_g3_phy_atpl360_coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c
  group thirdparty_g3_hal_SAM_atpl360
    ../../../../hal/SAM_atpl360/: hal.c
  group thirdparty_g3_pal_atpl360_g3macrt_source
    ../../../../pal/atpl360_g3macrt/source/: pal.c
  group thirdparty_g3_apps_adp_mac_serialized_app
    ../../: main.c
  group thirdparty_g3_bootstrap_wrapper_source
    ../../../../bootstrap_wrapper/source/: BootstrapWrapper.c
  group thirdparty_g3_adp
    ../../../../adp/: AdpConf.c
  group thirdparty_g3_routing_wrapper_source
    ../../../../routing_wrapper/source/: RoutingWrapper.c
  group thirdparty_g3_storage
    ../../../../storage/: storage.c
  group thirdparty_g3_hyal_source
    ../../../../hyal/source/: hyal.c
  group thirdparty_g3_mac_wrapper_source
    ../../../../mac_wrapper/source/: mac_wrapper.c
  group mbed-tls_library
    ../../../../../mbed-tls/library/: cipher.c aesni.c error.c ccm.c memory_buffer_alloc.c cipher_wrap.c debug_tls.c platform.c version.c aes_tls.c cmac.c timing.c oid_tls.c version_features.c gcm.c platform_util.c
  group sam_services_plc_buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c
  group sam_services_plc_usb_wrp
    ../../../../../../sam/services/plc/usb_wrp/: usb_wrp.c
  group sam_services_plc_pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c
  group sam_services_plc_pplc_if_atpl360
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c
  group sam_services_plc_usi
    ../../../../../../sam/services/plc/usi/: usi.c
  group sam_services_plc_busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c
  group sam_services_timer_1us
    ../../../../../../sam/services/timer_1us/: timer_1us.c
    ../../../../../../sam/services/timer_1us/hal_samg55/: timer_1us_hal.c
  group sam_services_rf_prf_if_at86rf215
    ../../../../../../sam/services/rf/prf_if/at86rf215/: prf_if.c
  group sam_services_flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c
  group sam_drivers_matrix
    ../../../../../../sam/drivers/matrix/: matrix.c
  group sam_drivers_pdc
    ../../../../../../sam/drivers/pdc/: pdc.c
  group sam_drivers_tc
    ../../../../../../sam/drivers/tc/: tc.c
  group sam_drivers_flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c
  group sam_drivers_wdt
    ../../../../../../sam/drivers/wdt/: wdt.c
  group sam_drivers_efc
    ../../../../../../sam/drivers/efc/: efc.c
  group sam_drivers_supc
    ../../../../../../sam/drivers/supc/: supc.c
  group sam_drivers_udp
    ../../../../../../sam/drivers/udp/: udp_device.c
  group sam_drivers_pmc
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam_drivers_usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam_drivers_pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam_drivers_adc
    ../../../../../../sam/drivers/adc/: adc2.c
  group sam_drivers_spi
    ../../../../../../sam/drivers/spi/: spi.c
  group sam_drivers_gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c
  group sam_boards_pl360g55cf_ek
    ../../../../../../sam/boards/pl360g55cf_ek/: init.c
  group common_components_rf_at86rf215_rf215_irq
    ../../../../../../common/components/rf/at86rf215/rf215_irq/: rf215_irq.c
  group common_components_rf_at86rf215_rf215_common
    ../../../../../../common/components/rf/at86rf215/rf215_common/: rf215_spi.c rf215_trx_ctl.c
  group common_components_rf_at86rf215_rf215_tx_rx
    ../../../../../../common/components/rf/at86rf215/rf215_tx_rx/: rf215_rx.c rf215_tx.c
  group common_components_rf_at86rf215_rf215_bbc
    ../../../../../../common/components/rf/at86rf215/rf215_bbc/: rf215_bbc.c
  group common_components_rf_at86rf215_rf215_fe
    ../../../../../../common/components/rf/at86rf215/rf215_fe/: rf215_fe.c
  group common_components_rf_at86rf215
    ../../../../../../common/components/rf/at86rf215/: at86rf215.c
    ../../../../../../common/components/rf/at86rf215/rf215_pll/: rf215_pll.c
  group common_components_rf_at86rf215_addons_sniffer_if_g3
    ../../../../../../common/components/rf/at86rf215/addons/sniffer_if/g3/: rf215_sniffer_if_g3.c
  group common_components_rf_at86rf215_addons_sniffer_if
    ../../../../../../common/components/rf/at86rf215/addons/sniffer_if/: rf215_sniffer_if.c
  group common_components_plc_atpl360_g3_mac_rt_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c
  group common_components_plc_atpl360_g3_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_boot.c atpl360_hal_spi.c atpl360.c
  group common_utils_stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common_utils_interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common_services_delay_sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c
  group common_services_clock_samg
    ../../../../../../common/services/clock/samg/: sysclk.c
  group common_services_usb_udc
    ../../../../../../common/services/usb/udc/: udc.c
  group common_services_usb_class_cdc_device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common_services_sleepmgr_sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group common_services_serial
    ../../../../../../common/services/serial/: usart_serial.c
  group sam_drivers_rstc
    ../../../../../../sam/drivers/rstc/: rstc.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2, Compiler:I/O:STDOUT 1.2.0
