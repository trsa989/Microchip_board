# Keil uVision project apps_gateway_coord_app_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAMG55J19 Atmel
  pack: Keil.SAMG_DFP.1.1.0
  cpu: IROM(0x00400000,0x80000) IRAM(0x20000000,0x28000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: apps_template_app
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: __G3_STACK__ BOARD=SAMG55_XPLAINED_PRO __SAMG55J19__ UDD_ENABLE __G3_GATEWAY__ __FREERTOS__ ARM_MATH_CM4=true
  c misc: --diag_suppress=66 --gnu
  c include: ..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\routing_wrapper\source;..\..\..\..\phy\atpl360\coup_tx_config\coup_params;..\..\..\..\..\..\sam\utils\fpu;..\..\..\..\adp\include;..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt;..\..\..\..\..\..\common\services\ioport;..\..\..;..\..\..\..\coordinator\include;..\..\..\..\..\..\common\services\usb\class\cdc\device;..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\include;..\..\..\..\..\..\sam\utils;..\..\..\..\..\..\common\services\usb;..\..\..\..\routing_loadng\source;..\..\..\..\routing_wrapper\include;..\..\..\..\bootstrap_lbp\include;..\..\..\..\mac_rt\include;..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\bootstrap_wrapper\source;..\..\..\..\..\..\sam\drivers\wdt;..\..\..\..\..\..\common\services\usb\udc;..\..\..\..\..\..\sam\services\plc\busart_if;..\..\..\..\..\cycloneTCP\cyclone_crypto;..\..\..\..\..\..\sam\boards;..\..\..\..\mac\include;..\..\..\..\common\source;..\..\..\..\..\..\sam\drivers\rstc;..\..\..\..\..\..\sam\services\plc\buart_if;..\..\..\..\..\..\sam\drivers\pmc;..\..\..\..\..\..\sam\drivers\pdc;..\..\..\..\..\..\sam\services\plc\usb_wrp;..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\source\templates;..\..\..\..\routing_loadng\include;..\..\..\..\..\..\sam\drivers\gpbr;..\..\..\..\..\..\common\utils;..\..\..\..\..\..\common\services\delay;..\..\..\..\..\..\common\services\usb\class\cdc;..\..;..\..\..\..\..\..\sam\boards\samg55_xplained_pro;..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\..\..\common\boards;..\..\..\..\bootstrap_lbp\source;..\..\..\..\..\mbed-tls\library;..\..\..\..\..\..\sam\drivers\supc;..\..\..\..\..\..\sam\drivers\adc;..\..\..\..\..\..\sam\drivers\udp;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt;..\..\..\..\..\freertos\freertos-7.3.0\source\include;..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\sam\drivers\pio;..\..\..\..\..\dlms\server\profile_g3;..\..\..\..\..\..\common\services\clock;..;..\..\..\..\bootstrap_wrapper\include;..\..\..\..\common\include;..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f;..\..\..\..\..\..\sam\services\plc\usi;..\..\..\..\..\..\common\services\sleepmgr;..\..\..\..\..\..\common\services\gpio;..\..\..\..\..\..\common\utils\stdio\stdio_udc;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt;..\..\..\..\..\..\sam\drivers\matrix;..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460_fcc_cen_b;..\..\..\..\oss;..\..\..\..;..\..\..\..\..\cycloneTCP\module_config;..\..\..\..\..\..\common\services\serial\sam_uart;..\..\..\..\..\..\sam\utils\header_files;..\..\..\..\..\cycloneTCP\atpl_extension;..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360;..\..\..\..\pal\atpl360_g3macrt\include;..\..\..\..\coordinator\source;..\..\..\..\..\..\sam\drivers\flexcom;..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\dlms\server\lib;..\..\..\..\..\..\sam\services\flash_efc;..\..\..\..\..\cycloneTCP\cyclone_tcp;..\..\..\..\..\..\sam\services\plc\pcrc;..\..\..\..\mac_wrapper\include;..\..\..\..\..\cycloneTCP\common;..\..\..\..\phy\atpl360\coup_tx_config;..\..\..\..\..\mbed-tls\include;..\..\..\..\..\..\sam\drivers\usart;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x400000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\samg55j19.sct
  group Startup
    ./: startup_SAMG55.s retarget.c system_samg55.c atpl_bin_multi.S
  group thirdparty_g3_libs_keil
    ../../../../libs/keil/: lib-g3-keil-loadng.lib lib-g3-keil-mac.lib lib-g3-keil-adp.lib
  group thirdparty_g3_common_source
    ../../../../common/source/: Logger.c Byte.c Timer.c Random.c QueueMng.c
  group thirdparty_g3_apps_gateway_coord_app
    ../../: dlms_app_dev.c main.c app_adp_mng.c dlms_srv_data.c
  group thirdparty_g3_crypto
    ../../../../crypto/: aes_wrapper.c cipher_wrapper.c eax.c
  group thirdparty_g3_coordinator_source
    ../../../../coordinator/source/: bs_functions.c bs_main.c
  group thirdparty_g3_oss
    ../../../../oss/: oss_if.c
  group thirdparty_g3_bootstrap_lbp_source
    ../../../../bootstrap_lbp/source/: ProtoEapPsk.c ProtoLbp.c ProcessLbp.c
  group thirdparty_g3_phy_atpl360_coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c
  group thirdparty_g3_hal_SAM_atpl360
    ../../../../hal/SAM_atpl360/: hal.c
  group thirdparty_g3_pal_atpl360_g3macrt_source
    ../../../../pal/atpl360_g3macrt/source/: pal.c
  group thirdparty_g3_adp
    ../../../../adp/: AdpConf.c
  group thirdparty_g3_routing_wrapper_source
    ../../../../routing_wrapper/source/: RoutingWrapper.c
  group thirdparty_g3_storage
    ../../../../storage/: storage.c
  group thirdparty_g3_bootstrap_wrapper_source
    ../../../../bootstrap_wrapper/source/: BootstrapWrapper.c
  group thirdparty_g3_mac_wrapper_source
    ../../../../mac_wrapper/source/: mac_wrapper.c
  group thirdparty_dlms_libs_keil
    ../../../../../dlms/libs/keil/: libsamM4-dlms-server-keil.lib
  group thirdparty_dlms_server_profile_g3
    ../../../../../dlms/server/profile_g3/: dlms_srv_data_example.c
  group thirdparty_cycloneTCP_cyclone_tcp_core
    ../../../../../cycloneTCP/cyclone_tcp/core/: tcp_timer.c tcp.c ethernet_misc.c udp.c ip.c tcp_misc.c nic.c ethernet.c raw_socket.c net.c socket.c net_mem.c ping.c tcp_fsm.c
  group thirdparty_cycloneTCP_cyclone_tcp_mibs
    ../../../../../cycloneTCP/cyclone_tcp/mibs/: mib2_module.c udp_mib_module.c udp_mib_impl.c tcp_mib_impl.c tcp_mib_module.c ip_mib_impl.c mib_common.c mib2_impl.c ip_mib_module.c
  group thirdparty_cycloneTCP_cyclone_tcp_mdns
    ../../../../../cycloneTCP/cyclone_tcp/mdns/: mdns_common.c mdns_responder.c mdns_client.c
  group thirdparty_cycloneTCP_cyclone_tcp_dns_sd
    ../../../../../cycloneTCP/cyclone_tcp/dns_sd/: dns_sd.c
  group thirdparty_cycloneTCP_cyclone_tcp_ppp
    ../../../../../cycloneTCP/cyclone_tcp/ppp/: pap.c ppp_fsm.c lcp.c chap.c ipv6cp.c ppp_debug.c ppp_hdlc.c ppp_misc.c ppp.c
  group thirdparty_cycloneTCP_cyclone_tcp_ipv6
    ../../../../../cycloneTCP/cyclone_tcp/ipv6/: mld.c ipv6_frag.c ipv6_routing.c ipv6_misc.c ipv6.c ndp_misc.c ipv6_pmtu.c icmpv6.c ndp.c ndp_router_adv.c slaac.c ndp_cache.c
  group thirdparty_cycloneTCP_cyclone_tcp_dns
    ../../../../../cycloneTCP/cyclone_tcp/dns/: dns_cache.c dns_common.c dns_debug.c dns_client.c
  group thirdparty_cycloneTCP_cyclone_tcp_drivers
    ../../../../../cycloneTCP/cyclone_tcp/drivers/: plc_buart.c
    ../../../../../cycloneTCP/cyclone_tcp/drivers/g3/: network_adapter_g3.c
  group thirdparty_cycloneTCP_cyclone_crypto_encoding
    ../../../../../cycloneTCP/cyclone_crypto/encoding/: oid.c asn1.c
  group thirdparty_cycloneTCP_common
    ../../../../../cycloneTCP/common/: date_time.c debug.c str.c cpu_endian.c os_port_none.c path.c
  group thirdparty_cycloneTCP_atpl_extension
    ../../../../../cycloneTCP/atpl_extension/: async_ping.c
  group mbed-tls_library
    ../../../../../mbed-tls/library/: aesni.c cipher.c error.c ccm.c cipher_wrap.c debug_tls.c platform.c version.c aes_tls.c memory_buffer_alloc.c cmac.c timing.c oid_tls.c version_features.c gcm.c platform_util.c
  group sam_services_plc_buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c
  group sam_services_plc_usb_wrp
    ../../../../../../sam/services/plc/usb_wrp/: usb_wrp.c
  group sam_services_plc_pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c
  group sam_services_plc_pplc_if_atpl360
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c
  group sam_services_plc_usi
    ../../../../../../sam/services/plc/usi/: usi.c
  group sam_services_plc_busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c
  group sam_services_flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c
  group sam_drivers_matrix
    ../../../../../../sam/drivers/matrix/: matrix.c
  group sam_drivers_pdc
    ../../../../../../sam/drivers/pdc/: pdc.c
  group sam_drivers_tc
    ../../../../../../sam/drivers/tc/: tc.c
  group sam_drivers_rstc
    ../../../../../../sam/drivers/rstc/: rstc.c
  group sam_drivers_flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c
  group sam_drivers_wdt
    ../../../../../../sam/drivers/wdt/: wdt.c
  group sam_drivers_efc
    ../../../../../../sam/drivers/efc/: efc.c
  group sam_drivers_supc
    ../../../../../../sam/drivers/supc/: supc.c
  group sam_drivers_spi
    ../../../../../../sam/drivers/spi/: spi.c
  group sam_drivers_udp
    ../../../../../../sam/drivers/udp/: udp_device.c
  group sam_drivers_pmc
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam_drivers_usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam_drivers_pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam_drivers_adc
    ../../../../../../sam/drivers/adc/: adc2.c
  group sam_drivers_gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c
  group sam_boards_samg55_xplained_pro
    ../../../../../../sam/boards/samg55_xplained_pro/: board_init.c
  group common_components_plc_atpl360_g3_mac_rt_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c
  group common_components_plc_atpl360_g3_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_boot.c atpl360_hal_spi.c atpl360.c
  group common_utils_stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common_utils_interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common_services_delay_sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c
  group common_services_usb_udc
    ../../../../../../common/services/usb/udc/: udc.c
  group common_services_usb_class_cdc_device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common_services_sleepmgr_sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group common_services_clock_samg
    ../../../../../../common/services/clock/samg/: sysclk.c
  group common_services_serial
    ../../../../../../common/services/serial/: usart_serial.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
