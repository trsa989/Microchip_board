<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_gateway_coord_app_flash.ewp</path>
	</project>
</workspace>
