# IAR project apps_dlms_app_meter_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CMS16C_0 Atmel ATSAM4CMS16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __G3_STACK__; __FREERTOS__; BOARD=ATPL360MB; __SAM4CMS16C_0__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\services\plc\pcrc; ..\..\..\..\..\..\sam\services\plc\buart_if; ..\..\..\..\..\..\sam\drivers\rtc; ..\..\..\..\..\..\common\services\ioport; ..\..\..; ..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\..\..\sam\components\display\c0216CiZ; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\sam\services\plc\at45db32; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\sam\drivers\uart; ..; ..\..\..\..\..\..\sam\drivers\ipc; ..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\..\sam\boards\atpl360mb; ..\..\..\..\hdlc; ..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\twi; ..\..\..\..\..\dlms\server\profile_g3_meter; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\common\source; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\addons\serial_buffer; ..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\oss; ..\..\..\..\..\..\common\services\clock; ..\..; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\..\..\sam\utils\cmsis\sam4cm\source\templates; ..\..\..\..\..\..\sam\services\plc\usi; ..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\sam\drivers\twi; ..\..\..\..\common\include; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..; ..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\sam\utils\cmsis\sam4cm\include; ..\..\..\..\..\..\sam\services\plc\busart_if; ..\..\..\..\..\metrology\meter_utils\v_1_43; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\dlms\server\lib; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\common\components\memory\eeprom\at24cxx; ..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_dlms_app_meter_flash.bin
  ILINK.IlinkOutputFile: apps_dlms_app_meter_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\sam\utils\linker_scripts\sam4cm\iar\sam4cms16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/dlms/libs/iar
    ../../../../../dlms/libs/iar/: libsamM4-dlms-server-iar.a
  group thirdparty/dlms/server/profile_g3_meter
    ../../../../../dlms/server/profile_g3_meter/: dlms_srv_data_example.c dlms_srv_data_example.h
  group thirdparty/dlms/server/lib
    ../../../../../dlms/server/lib/: dlms_srv_cnf.h dlms_srv_types.h dlms_srv_lib.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../freertos/freertos-7.3.0/source/: queue.c timers.c FreeRTOS_CLI.c tasks.c list.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam
    ../../../../../freertos/freertos-7.3.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../freertos/freertos-7.3.0/source/include/: portable.h projdefs.h FreeRTOS.h FreeRTOS_CLI.h mpu_wrappers.h timers.h StackMacros.h croutine.h list.h queue.h task.h semphr.h
  group thirdparty/g3/apps
    ../../../: conf_global.h
  group thirdparty/g3/apps/dlms_app_meter
    ../../: main.c app_metering.c app_dispatcher.c dlms_dev.c simple_mgmt.c dlms_srv_data.c app_dispatcher.h g3_app_config.h dlms_dev.h dlms_srv_data.h app_metering.h simple_mgmt.h
  group thirdparty/g3/apps/dlms_app_meter/sam4cms16c_atpl360mb
    ../: conf_oss.h conf_project.h conf_clock.h conf_busart_if.h conf_buart_if.h conf_usi.h conf_sleepmgr.h conf_c0216CiZ.h conf_board.h FreeRTOSConfig.h conf_hal.h conf_uart_serial.h
  group thirdparty/g3/apps/dlms_app_meter/sam4cms16c_atpl360mb/iar
    ./: asf.h
  group thirdparty/g3/addons/serial_buffer
    ../../../../addons/serial_buffer/: serial_buffer.c serial_buffer.h
  group thirdparty/g3/common/source
    ../../../../common/source/: Timer.c Random.c QueueMng.c Byte.c Logger.c
  group thirdparty/g3/common/include
    ../../../../common/include/: Byte.h Logger.h QueueMng.h g3_stack_version.h Timer.h Random.h
  group thirdparty/g3/hal
    ../../../../hal/: hal.h
  group thirdparty/g3/hal/SAM_atpl360
    ../../../../hal/SAM_atpl360/: hal.c hal.h
  group thirdparty/g3/oss
    ../../../../oss/: oss_if.c oss_if.h
  group thirdparty/g3/hdlc
    ../../../../hdlc/: hdlc.c hdlc.h
  group thirdparty/metrology/meter_utils/v_1_43
    ../../../../../metrology/meter_utils/v_1_43/: rtcproc.c shared_memory.c met_utils.c metrology.c shared_memory.h metrology.h rtcproc.h met_utils.h
  group sam/services/plc/buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/plc/at45db32
    ../../../../../../sam/services/plc/at45db32/: at45db32.c at45db32.h
  group sam/services/plc/pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/usi
    ../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4cm/source/templates
    ../../../../../../sam/utils/cmsis/sam4cm/source/templates/: system_sam4cm.c
  group sam/utils/cmsis/sam4cm/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4cm/source/templates/iar/: startup_sam4cm.c
  group sam/utils/cmsis/sam4cm/include
    ../../../../../../sam/utils/cmsis/sam4cm/include/: sam4cms8c_1.h sam4cmp16c_0.h sam4cms4c_1.h sam4cms4c_0.h sam4cms8c_0.h system_sam4cm.h sam4cm.h sam4cmp8c_0.h sam4cms16c_0.h sam4cmp16c_1.h sam4cmp8c_1.h sam4cms16c_1.h
  group sam/utils/cmsis/sam4cm/include/instance
    ../../../../../../sam/utils/cmsis/sam4cm/include/instance/: tc1.h usart0.h aes.h rstc.h slcdc.h twi1.h twi0.h piob.h uart0.h adc.h rswdt.h chipid.h pmc.h cmcc1.h usart2.h matrix1.h pioa.h pwm.h pioc.h tc0.h ipc0.h rtc.h spi0.h matrix0.h smc1.h ipc1.h icm.h usart3.h wdt.h supc.h trng.h spi1.h cmcc0.h usart1.h uart1.h smc0.h efc.h rtt.h gpbr.h
  group sam/utils/cmsis/sam4cm/include/component
    ../../../../../../sam/utils/cmsis/sam4cm/include/component/: wdt.h pio.h rswdt.h tc.h smc.h rtt.h usart.h trng.h rstc.h aes.h pdc.h rtc.h adc.h efc.h chipid.h ipc.h gpbr.h cmcc.h pwm.h supc.h pmc.h spi.h slcdc.h icm.h uart.h matrix.h twi.h
  group sam/utils/cmsis/sam4cm/include/pio
    ../../../../../../sam/utils/cmsis/sam4cm/include/pio/: sam4cmp16c.h sam4cms16c.h sam4cms8c.h sam4cmp8c.h sam4cms4c.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/trng
    ../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/ipc
    ../../../../../../sam/drivers/ipc/: ipc.c ipc.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/rtc
    ../../../../../../sam/drivers/rtc/: rtc.c rtc.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/adc
    ../../../../../../sam/drivers/adc/: adc.c adc_sam3u.c adc.h
  group sam/drivers/twi
    ../../../../../../sam/drivers/twi/: twi.c twi.h
  group sam/components/display/c0216CiZ
    ../../../../../../sam/components/display/c0216CiZ/: c0216CiZ.c c0216CiZ.h
  group sam/boards/atpl360mb
    ../../../../../../sam/boards/atpl360mb/: init.c atpl360mb.h led.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/sam4cm
    ../../../../../../common/services/clock/sam4cm/: sysclk.c genclk.h sysclk.h pll.h osc.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/twi
    ../../../../../../common/services/twi/: twi_slave.h twi_master.h
  group common/services/twi/sam_twi
    ../../../../../../common/services/twi/sam_twi/: twi_slave.h twi_master.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/components/memory/eeprom/at24cxx
    ../../../../../../common/components/memory/eeprom/at24cxx/: at24cxx.c at24cxx.h
  group common/boards
    ../../../../../../common/boards/: board.h
