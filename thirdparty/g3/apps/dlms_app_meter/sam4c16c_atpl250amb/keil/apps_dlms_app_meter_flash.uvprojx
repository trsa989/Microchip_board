# Keil uVision project apps_dlms_app_meter_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAM4C16C:CM4 P0 Atmel
  pack: Keil.SAM4_DFP.1.4.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x01000000,0x100000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: apps_template_app
  c flags: Optim=3 oTime=1 uC99=1 wLevel=2
  c define: __G3_STACK__ __FREERTOS__ BOARD=ATPL250AMB ARM_MATH_CM4=true __SAM4C16C_0__
  c misc: --diag_suppress=66
  c include: ..\..\..\..\..\..\sam\services\plc\pcrc;..\..\..\..\..\..\sam\services\plc\buart_if;..;..\..\..\..\..\..\common\services\ioport;..\..\..;..\..\..\..\..\freertos\freertos-7.3.0\source\include;..\..\..\..\..\..\sam\utils;..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\common\boards;..\..\..\..\..\..\sam\drivers\pdc;..\..\..\..\..\..\sam\services\flash_efc;..\..\..\..\..\..\sam\boards;..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\..\..\sam\drivers\uart;..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam;..\..\..\..\..\..\sam\drivers\pmc;..\..\..\..\hdlc;..\..\..\..\..\..\sam\utils\cmsis\sam4c\include;..\..\..\..\..\..\sam\drivers\gpbr;..\..\..\..\..\..\common\utils;..\..\..\..\..\dlms\server\profile_g3_meter;..\..\..\..\..\..\sam\boards\atpl250amb;..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\common\source;..\..\..\..\..\..\sam\drivers\adc;..\..\..\..\..\..\sam\drivers\pio;..\..\..\..\..\..\sam\drivers\supc;..\..\..\..\oss;..\..\..\..\..\..\common\services\clock;..\..;..\..\..\..\..\..\sam\drivers\trng;..\..\..\..\..\..\sam\services\plc\usi;..\..\..\..\..\..\sam\utils\cmsis\sam4c\source\templates;..\..\..\..\addons\serial_buffer;..\..\..\..\..\..\common\services\gpio;..\..\..\..\common\include;..\..\..\..\..\..\sam\utils\header_files;..\..\..\..;..\..\..\..\..\..\common\services\serial\sam_uart;..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\sam\services\plc\busart_if;..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\dlms\server\lib;..\..\..\..\..\..\sam\services\plc\at45db32;..\..\..\..\..\..\sam\drivers\usart;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x1000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\sam4c16c.sct
  group Startup
    ./: startup_SAM4C.s retarget.c system_sam4c.c
  group thirdparty_dlms_libs_keil
    ../../../../../dlms/libs/keil/: libsamM4-dlms-server-keil.lib
  group thirdparty_dlms_server_profile_g3_meter
    ../../../../../dlms/server/profile_g3_meter/: dlms_srv_data_example.c
  group g3_apps_dlms_app_meter
    ../../: main.c app_metering.c app_dispatcher.c dlms_dev.c simple_mgmt.c dlms_srv_data.c
  group g3_addons_serial_buffer
    ../../../../addons/serial_buffer/: serial_buffer.c
  group g3_common_source
    ../../../../common/source/: Timer.c Random.c QueueMng.c Byte.c Logger.c
  group g3_hal_SAM
    ../../../../hal/SAM/: hal.c
  group g3_oss
    ../../../../oss/: oss_if.c
  group g3_hdlc
    ../../../../hdlc/: hdlc.c
  group sam_services_plc_buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c
  group sam_services_plc_busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c
  group sam_services_plc_pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c
  group sam_services_plc_at45db32
    ../../../../../../sam/services/plc/at45db32/: at45db32.c
  group sam_services_plc_usi
    ../../../../../../sam/services/plc/usi/: usi.c
  group sam_services_flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c
  group sam_drivers_usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam_drivers_pdc
    ../../../../../../sam/drivers/pdc/: pdc.c
  group sam_drivers_tc
    ../../../../../../sam/drivers/tc/: tc.c
  group sam_drivers_trng
    ../../../../../../sam/drivers/trng/: trng.c
  group sam_drivers_uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam_drivers_efc
    ../../../../../../sam/drivers/efc/: efc.c
  group sam_drivers_supc
    ../../../../../../sam/drivers/supc/: supc.c
  group sam_drivers_gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c
  group sam_drivers_pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam_drivers_pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam_drivers_adc
    ../../../../../../sam/drivers/adc/: adc.c adc_sam3u.c
  group sam_boards_atpl250amb
    ../../../../../../sam/boards/atpl250amb/: init.c
  group common_utils_stdio
    ../../../../../../common/utils/stdio/: read.c write.c
  group common_utils_interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common_services_clock_sam4c
    ../../../../../../common/services/clock/sam4c/: sysclk.c
  group common_services_serial
    ../../../../../../common/services/serial/: usart_serial.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
