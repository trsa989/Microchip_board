# IAR project apps_dlms_app_meter_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4C16C_0 Atmel ATSAM4C16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __G3_STACK__; __FREERTOS__; BOARD=ATPL250AMB; ARM_MATH_CM4=true; __SAM4C16C_0__
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\services\plc\pcrc; ..\..\..\..\..\..\sam\services\plc\buart_if; ..; ..\..\..\..\..\..\common\services\ioport; ..\..\..; ..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam; ..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\hdlc; ..\..\..\..\..\..\sam\utils\cmsis\sam4c\include; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\dlms\server\profile_g3_meter; ..\..\..\..\..\..\sam\boards\atpl250amb; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\common\source; ..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\oss; ..\..\..\..\..\..\common\services\clock; ..\..; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\..\..\sam\services\plc\usi; ..\..\..\..\..\..\sam\utils\cmsis\sam4c\source\templates; ..\..\..\..\addons\serial_buffer; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\common\include; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..; ..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\sam\services\plc\busart_if; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\dlms\server\lib; ..\..\..\..\..\..\sam\services\plc\at45db32; ..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_dlms_app_meter_flash.bin
  ILINK.IlinkOutputFile: apps_dlms_app_meter_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\sam\utils\linker_scripts\sam4c\iar\sam4c16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/dlms/libs/iar
    ../../../../../dlms/libs/iar/: libsamM4-dlms-server-iar.a
  group thirdparty/dlms/server/profile_g3_meter
    ../../../../../dlms/server/profile_g3_meter/: dlms_srv_data_example.c dlms_srv_data_example.h
  group thirdparty/dlms/server/lib
    ../../../../../dlms/server/lib/: dlms_srv_types.h dlms_srv_cnf.h dlms_srv_lib.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../freertos/freertos-7.3.0/source/: queue.c timers.c FreeRTOS_CLI.c tasks.c list.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam
    ../../../../../freertos/freertos-7.3.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../freertos/freertos-7.3.0/source/include/: portable.h projdefs.h FreeRTOS.h queue.h FreeRTOS_CLI.h mpu_wrappers.h timers.h StackMacros.h croutine.h list.h task.h semphr.h
  group thirdparty/g3/apps
    ../../../: conf_global.h
  group thirdparty/g3/apps/dlms_app_meter
    ../../: main.c app_metering.c app_dispatcher.c dlms_dev.c simple_mgmt.c dlms_srv_data.c app_dispatcher.h g3_app_config.h dlms_dev.h dlms_srv_data.h app_metering.h simple_mgmt.h
  group thirdparty/g3/apps/dlms_app_meter/sam4c16c_atpl250amb
    ../: conf_oss.h conf_project.h conf_clock.h conf_busart_if.h conf_buart_if.h conf_sleepmgr.h conf_pplc_if.h conf_board.h FreeRTOSConfig.h conf_hal.h conf_uart_serial.h conf_usi.h
  group thirdparty/g3/apps/dlms_app_meter/sam4c16c_atpl250amb/iar
    ./: asf.h
  group thirdparty/g3/addons/serial_buffer
    ../../../../addons/serial_buffer/: serial_buffer.c serial_buffer.h
  group thirdparty/g3/common/source
    ../../../../common/source/: Timer.c Random.c QueueMng.c Byte.c Logger.c
  group thirdparty/g3/common/include
    ../../../../common/include/: Byte.h Logger.h QueueMng.h Timer.h Random.h g3_stack_version.h
  group thirdparty/g3/hal
    ../../../../hal/: hal.h
  group thirdparty/g3/hal/SAM
    ../../../../hal/SAM/: hal.c hal.h
  group thirdparty/g3/oss
    ../../../../oss/: oss_if.c oss_if.h
  group thirdparty/g3/hdlc
    ../../../../hdlc/: hdlc.c hdlc.h
  group sam/services/plc/buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/plc/pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/at45db32
    ../../../../../../sam/services/plc/at45db32/: at45db32.c at45db32.h
  group sam/services/plc/usi
    ../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4c/source/templates
    ../../../../../../sam/utils/cmsis/sam4c/source/templates/: system_sam4c.c
  group sam/utils/cmsis/sam4c/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4c/source/templates/iar/: startup_sam4c.c
  group sam/utils/cmsis/sam4c/include
    ../../../../../../sam/utils/cmsis/sam4c/include/: sam4c8c_1.h sam4c4c_0.h sam4c32c_1.h sam4c32e_1.h sam4c4c_1.h sam4c32c_0.h sam4c.h system_sam4c.h sam4c32e_0.h sam4c16c_1.h sam4c8c_0.h sam4c16c_0.h
  group sam/utils/cmsis/sam4c/include/component
    ../../../../../../sam/utils/cmsis/sam4c/include/component/: component_tc.h component_ipc.h component_chipid.h component_spi.h component_smc.h component_supc.h component_trng.h component_rtt.h component_uotghs.h component_twi.h component_slcdc.h component_pio.h component_usart.h component_gpbr.h component_cmcc.h component_adc.h component_matrix.h component_wdt.h component_pwm.h component_rswdt.h component_pdc.h component_rstc.h component_uart.h component_icm.h component_pmc.h component_aes.h component_efc.h component_rtc.h
  group sam/utils/cmsis/sam4c/include/instance
    ../../../../../../sam/utils/cmsis/sam4c/include/instance/: instance_ipc1.h instance_efc.h instance_rstc.h instance_spi0.h instance_pioc.h instance_rtc.h instance_twi0.h instance_matrix1.h instance_uart1.h instance_piod.h instance_slcdc.h instance_ipc0.h instance_trng.h instance_gpbr.h instance_piob.h instance_pwm.h instance_uart0.h instance_aes.h instance_tc0.h instance_cmcc1.h instance_supc.h instance_pmc.h instance_adc.h instance_chipid.h instance_rswdt.h instance_uotghs.h instance_efc1.h instance_usart0.h instance_usart2.h instance_usart4.h instance_smc0.h instance_rtt.h instance_wdt.h instance_icm.h instance_cmcc0.h instance_spi1.h instance_tc1.h instance_twi1.h instance_efc0.h instance_matrix0.h instance_usart1.h instance_usart3.h instance_smc1.h instance_pioa.h
  group sam/utils/cmsis/sam4c/include/pio
    ../../../../../../sam/utils/cmsis/sam4c/include/pio/: pio_sam4c32e.h pio_sam4c32c.h pio_sam4c4c.h pio_sam4c16c.h pio_sam4c8c.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h mrepeat.h stringz.h tpaste.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/trng
    ../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/adc
    ../../../../../../sam/drivers/adc/: adc.c adc_sam3u.c adc.h
  group sam/boards/atpl250amb
    ../../../../../../sam/boards/atpl250amb/: init.c led.h atpl250amb.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: pll.h sysclk.h osc.h genclk.h
  group common/services/clock/sam4c
    ../../../../../../common/services/clock/sam4c/: sysclk.c osc.h pll.h sysclk.h genclk.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
