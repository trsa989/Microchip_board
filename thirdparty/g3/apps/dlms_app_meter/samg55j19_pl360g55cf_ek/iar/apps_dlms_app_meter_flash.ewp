# IAR project apps_dlms_app_meter_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __G3_STACK__; __SAMG55J19__; UDD_ENABLE; BOARD=PL360G55CF_EK; __FREERTOS__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\services\plc\pcrc; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\sam\services\plc\buart_if; ..\..\..\..\..\..\common\services\ioport; ..\..\..; ..\..\..\..\..\..\common\services\usb\class\cdc\device; ..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\include; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\common\services\usb; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\sam\services\plc\usb_wrp; ..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\sam\drivers\wdt; ..\..\..\..\..\..\common\services\usb\udc; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\common\source; ..\..\..\..\addons\serial_buffer; ..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\..\sam\boards\pl360g55cf_ek; ..\..\..\..\hdlc; ..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\source\templates; ..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\usb\class\cdc; ..\..\..\..\..\dlms\server\profile_g3_meter; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\sam\drivers\udp; ..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\oss; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\flexcom; ..\..; ..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f; ..\..\..\..\..\..\sam\services\plc\usi; ..\..\..\..\..\..\common\services\gpio; ..\..\..\..\common\include; ..\..\..\..\..\..\sam\drivers\matrix; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..; ..; ..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\sam\services\plc\busart_if; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\dlms\server\lib; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\common\utils\stdio\stdio_udc; ..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_dlms_app_meter_flash.bin
  ILINK.IlinkOutputFile: apps_dlms_app_meter_flash.out
  ILINK.IlinkIcfFile: ..\..\..\linker_scripts\iar\samg55_flash_isp.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/dlms/libs/iar
    ../../../../../dlms/libs/iar/: libsamM4-dlms-server-iar.a
  group thirdparty/dlms/server/profile_g3_meter
    ../../../../../dlms/server/profile_g3_meter/: dlms_srv_data_example.c dlms_srv_data_example.h
  group thirdparty/dlms/server/lib
    ../../../../../dlms/server/lib/: dlms_srv_types.h dlms_srv_cnf.h dlms_srv_lib.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../freertos/freertos-7.3.0/source/: queue.c timers.c FreeRTOS_CLI.c tasks.c list.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f
    ../../../../../freertos/freertos-7.3.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../freertos/freertos-7.3.0/source/include/: portable.h projdefs.h FreeRTOS.h queue.h FreeRTOS_CLI.h mpu_wrappers.h timers.h StackMacros.h croutine.h list.h task.h semphr.h
  group thirdparty/g3/addons/serial_buffer
    ../../../../addons/serial_buffer/: serial_buffer.c serial_buffer.h
  group thirdparty/g3/common/source
    ../../../../common/source/: Timer.c Random.c QueueMng.c Byte.c Logger.c
  group thirdparty/g3/common/include
    ../../../../common/include/: Byte.h Logger.h QueueMng.h Random.h g3_stack_version.h Timer.h
  group thirdparty/g3/hal
    ../../../../hal/: hal.h
  group thirdparty/g3/hal/SAM_atpl360
    ../../../../hal/SAM_atpl360/: hal.c hal.h
  group thirdparty/g3/apps
    ../../../: conf_global.h
  group thirdparty/g3/apps/dlms_app_meter
    ../../: app_dispatcher.c dlms_dev.c main.c simple_mgmt.c dlms_srv_data.c app_dispatcher.h g3_app_config.h dlms_dev.h dlms_srv_data.h simple_mgmt.h
  group thirdparty/g3/apps/dlms_app_meter/samg55j19_pl360g55cf_ek
    ../: conf_oss.h conf_project.h conf_clock.h conf_busart_if.h conf_buart_if.h conf_usb.h conf_sleepmgr.h conf_pplc_if.h conf_board.h conf_hal.h FreeRTOSConfig.h conf_uart_serial.h conf_usi.h
  group thirdparty/g3/apps/dlms_app_meter/samg55j19_pl360g55cf_ek/iar
    ./: asf.h
  group thirdparty/g3/oss
    ../../../../oss/: oss_if.c oss_if.h
  group thirdparty/g3/hdlc
    ../../../../hdlc/: hdlc.c hdlc.h
  group sam/services/plc/buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/plc/usb_wrp
    ../../../../../../sam/services/plc/usb_wrp/: usb_wrp.c usb_wrp.h
  group sam/services/plc/pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/usi
    ../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/drivers/udp
    ../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/wdt
    ../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/adc
    ../../../../../../sam/drivers/adc/: adc2.c adc2.h
  group sam/drivers/matrix
    ../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../../sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../../sam/utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../../sam/utils/cmsis/samg/samg55/include/: samg55j18.h samg55g18.h samg55g19.h samg55.h system_samg55.h samg55j19.h samg55n19.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../../sam/utils/cmsis/samg/samg55/include/pio/: samg55g19.h samg55n19.h samg55j19.h samg55g18.h samg55j18.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../../sam/utils/cmsis/samg/samg55/include/instance/: pmc.h twi5.h flexcom0.h crccu.h usart0.h udp.h usart7.h pdmic1.h flexcom6.h wdt.h cmcc.h usart2.h twi7.h uhp.h supc.h usart3.h i2sc0.h piob.h efc.h spi5.h twi6.h flexcom7.h rtt.h flexcom5.h mem2mem.h matrix.h tc0.h twi3.h rstc.h spi7.h twi1.h spi1.h spi3.h usart5.h i2sc1.h chipid.h spi4.h flexcom3.h flexcom1.h tc1.h flexcom4.h pdmic0.h twi2.h spi6.h twi0.h spi0.h pioa.h spi2.h adc.h rtc.h usart6.h usart1.h usart4.h gpbr.h flexcom2.h twi4.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../../sam/utils/cmsis/samg/samg55/include/component/: uhp.h pmc.h rstc.h supc.h matrix.h efc.h cmcc.h flexcom.h rtc.h adc.h i2sc.h crccu.h pio.h pdmic.h mem2mem.h udp.h pdc.h usart.h gpbr.h spi.h rtt.h chipid.h twi.h tc.h wdt.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h mrepeat.h stringz.h tpaste.h
  group sam/boards/pl360g55cf_ek
    ../../../../../../sam/boards/pl360g55cf_ek/: init.c led.h pl360g55cf_ek.h
  group common/services/usb
    ../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/udc
    ../../../../../../common/services/usb/udc/: udc.c udc_desc.h udc.h udd.h udi.h
  group common/services/clock
    ../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/samg
    ../../../../../../common/services/clock/samg/: sysclk.c osc.h pll.h genclk.h sysclk.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_udc
    ../../../../../../common/utils/stdio/stdio_udc/: stdio_udc.h
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../../common/boards/: board.h
