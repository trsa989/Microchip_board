# Keil uVision project apps_dlms_app_meter_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAMG55J19 Atmel
  pack: Keil.SAMG_DFP.1.1.0
  cpu: IROM(0x00400000,0x80000) IRAM(0x20000000,0x28000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: apps_template_app
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: __G3_STACK__ __SAMG55J19__ UDD_ENABLE BOARD=PL360G55CF_EK __FREERTOS__ ARM_MATH_CM4=true
  c misc: --diag_suppress=66 --gnu
  c include: ..\..\..\..\..\..\sam\services\plc\pcrc;..\..\..\..\..\..\sam\utils\fpu;..\..\..\..\..\..\sam\services\plc\buart_if;..\..\..\..\..\..\common\services\ioport;..\..\..;..\..\..\..\..\..\common\services\usb\class\cdc\device;..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\include;..\..\..\..\..\..\sam\utils;..\..\..\..\..\..\common\services\usb;..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\sam\services\plc\usb_wrp;..\..\..\..\..\..\common\boards;..\..\..\..\..\..\sam\drivers\wdt;..\..\..\..\..\..\common\services\usb\udc;..\..\..\..\..\..\sam\drivers\pdc;..\..\..\..\..\..\sam\boards;..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\common\source;..\..\..\..\addons\serial_buffer;..\..\..\..\..\..\sam\drivers\pmc;..\..\..\..\..\..\sam\boards\pl360g55cf_ek;..\..\..\..\hdlc;..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\source\templates;..\..\..\..\..\..\sam\drivers\pio;..\..\..\..\..\..\sam\drivers\gpbr;..\..\..\..\..\..\common\utils;..\..\..\..\..\..\common\services\usb\class\cdc;..\..\..\..\..\dlms\server\profile_g3_meter;..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\..\..\sam\drivers\adc;..\..\..\..\..\..\sam\drivers\udp;..\..\..\..\..\freertos\freertos-7.3.0\source\include;..\..\..\..\..\..\sam\drivers\supc;..\..\..\..\oss;..\..\..\..\..\..\common\services\clock;..\..\..\..\..\..\sam\drivers\flexcom;..\..;..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f;..\..\..\..\..\..\sam\services\plc\usi;..\..\..\..\..\..\common\services\gpio;..\..\..\..\common\include;..\..\..\..\..\..\sam\drivers\matrix;..\..\..\..\..\..\sam\utils\header_files;..\..\..\..;..;..\..\..\..\..\..\common\services\serial\sam_uart;..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\sam\services\plc\busart_if;..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\dlms\server\lib;..\..\..\..\..\..\sam\services\flash_efc;..\..\..\..\..\..\common\services\sleepmgr;..\..\..\..\..\..\common\utils\stdio\stdio_udc;..\..\..\..\..\..\sam\drivers\usart;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x400000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\samg55j19.sct
  group Startup
    ./: startup_SAMG55.s retarget.c system_samg55.c atpl_bin_multi.S
  group thirdparty_dlms_libs_keil
    ../../../../../dlms/libs/keil/: libsamM4-dlms-server-keil.lib
  group thirdparty_dlms_server_profile_g3_meter
    ../../../../../dlms/server/profile_g3_meter/: dlms_srv_data_example.c
  group g3_addons_serial_buffer
    ../../../../addons/serial_buffer/: serial_buffer.c
  group g3_common_source
    ../../../../common/source/: Timer.c Random.c QueueMng.c Byte.c Logger.c
  group g3_hal_SAM_atpl360
    ../../../../hal/SAM_atpl360/: hal.c
  group g3_apps_dlms_app_meter
    ../../: app_dispatcher.c dlms_dev.c main.c simple_mgmt.c dlms_srv_data.c
  group g3_oss
    ../../../../oss/: oss_if.c
  group g3_hdlc
    ../../../../hdlc/: hdlc.c
  group sam_services_plc_buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c
  group sam_services_plc_busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c
  group sam_services_plc_usb_wrp
    ../../../../../../sam/services/plc/usb_wrp/: usb_wrp.c
  group sam_services_plc_pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c
  group sam_services_plc_usi
    ../../../../../../sam/services/plc/usi/: usi.c
  group sam_services_flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c
  group sam_drivers_udp
    ../../../../../../sam/drivers/udp/: udp_device.c
  group sam_drivers_wdt
    ../../../../../../sam/drivers/wdt/: wdt.c
  group sam_drivers_adc
    ../../../../../../sam/drivers/adc/: adc2.c
  group sam_drivers_matrix
    ../../../../../../sam/drivers/matrix/: matrix.c
  group sam_drivers_pdc
    ../../../../../../sam/drivers/pdc/: pdc.c
  group sam_drivers_tc
    ../../../../../../sam/drivers/tc/: tc.c
  group sam_drivers_gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c
  group sam_drivers_efc
    ../../../../../../sam/drivers/efc/: efc.c
  group sam_drivers_supc
    ../../../../../../sam/drivers/supc/: supc.c
  group sam_drivers_pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam_drivers_pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam_drivers_flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c
  group sam_drivers_usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam_boards_pl360g55cf_ek
    ../../../../../../sam/boards/pl360g55cf_ek/: init.c
  group common_services_usb_class_cdc_device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common_services_usb_udc
    ../../../../../../common/services/usb/udc/: udc.c
  group common_services_clock_samg
    ../../../../../../common/services/clock/samg/: sysclk.c
  group common_services_sleepmgr_sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group common_services_serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common_utils_interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common_utils_stdio
    ../../../../../../common/utils/stdio/: write.c read.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
