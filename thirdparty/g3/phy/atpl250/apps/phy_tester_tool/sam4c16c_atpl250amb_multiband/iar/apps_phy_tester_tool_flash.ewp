# IAR project apps_phy_tester_tool_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4C16C_0 Atmel ATSAM4C16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __G3_STACK__; __FREERTOS__; BOARD=ATPL250AMB; ARM_MATH_CM4=true; __SAM4C16C_0__
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\..\..\sam\services\plc\pcrc; ..\..\..\..\..\..\..\..\sam\services\plc\buart_if; ..\..\..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\..\..\..\..\sam\utils; ..\..; ..\..\..\..\..\..\..\..\sam\boards\atpl250amb; ..\..\..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\..\..\sam\boards; ..\..\..\..\addons\serial_if; ..\..\..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam; ..\..\..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\..\..\..\sam\services\plc\pplc_if\atpl250_multiband; ..\..\..\..\..\..\..\..\sam\services\plc\usi; ..\..\..\..\..\..\..\..\sam\utils\cmsis\sam4c\include; ..\..\..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\include_multiband; ..\..\..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\..\oss; ..\..\..\..\..\..\..\..\common\services\clock; ..\..\..\..\module_config; ..\..\..\..\..\..\..\..\sam\drivers\trng; ..; ..\..\..\..\..\..\..\..\sam\utils\cmsis\sam4c\source\templates; ..\..\..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..; ..\..\..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\..\..\sam\services\plc\busart_if; ..\..\..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_phy_tester_tool_flash.bin
  ILINK.IlinkOutputFile: apps_phy_tester_tool_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\..\sam\utils\linker_scripts\sam4c\iar\sam4c16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/supc
    ../../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/gpbr
    ../../../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/efc
    ../../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/trng
    ../../../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/aes
    ../../../../../../../../sam/drivers/aes/: aes.c aes.h
  group sam/drivers/aes/example
    ../../../../../../../../sam/drivers/aes/example/: aes_example.h
  group sam/drivers/adc
    ../../../../../../../../sam/drivers/adc/: adc.c adc_sam3u.c adc.h
  group sam/services/plc/busart_if
    ../../../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/plc/buart_if
    ../../../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/pplc_if/atpl250_multiband
    ../../../../../../../../sam/services/plc/pplc_if/atpl250_multiband/: pplc_if.c pplc_if.h
  group sam/services/plc/usi
    ../../../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/plc/pcrc
    ../../../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/flash_efc
    ../../../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/utils
    ../../../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4c/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4c/source/templates/: system_sam4c.c
  group sam/utils/cmsis/sam4c/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4c/source/templates/iar/: startup_sam4c.c
  group sam/utils/cmsis/sam4c/include
    ../../../../../../../../sam/utils/cmsis/sam4c/include/: sam4c8c_1.h sam4c32e_1.h sam4c32c_1.h sam4c4c_1.h sam4c32c_0.h sam4c.h sam4c4c_0.h sam4c32e_0.h system_sam4c.h sam4c8c_0.h sam4c16c_1.h sam4c16c_0.h
  group sam/utils/cmsis/sam4c/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4c/include/instance/: instance_piod.h instance_ipc1.h instance_tc1.h instance_rstc.h instance_spi0.h instance_pioc.h instance_twi0.h instance_cmcc1.h instance_slcdc.h instance_uart1.h instance_matrix1.h instance_efc.h instance_ipc0.h instance_gpbr.h instance_trng.h instance_pwm.h instance_supc.h instance_tc0.h instance_uart0.h instance_aes.h instance_pmc.h instance_adc.h instance_efc1.h instance_uotghs.h instance_usart0.h instance_rswdt.h instance_rtc.h instance_usart2.h instance_chipid.h instance_usart4.h instance_smc0.h instance_wdt.h instance_cmcc0.h instance_icm.h instance_rtt.h instance_spi1.h instance_twi1.h instance_piob.h instance_efc0.h instance_usart1.h instance_matrix0.h instance_usart3.h instance_smc1.h instance_pioa.h
  group sam/utils/cmsis/sam4c/include/component
    ../../../../../../../../sam/utils/cmsis/sam4c/include/component/: component_tc.h component_chipid.h component_trng.h component_supc.h component_smc.h component_rtt.h component_pmc.h component_uotghs.h component_twi.h component_usart.h component_slcdc.h component_pio.h component_wdt.h component_gpbr.h component_pwm.h component_cmcc.h component_matrix.h component_adc.h component_rswdt.h component_ipc.h component_uart.h component_rstc.h component_pdc.h component_icm.h component_aes.h component_efc.h component_rtc.h component_spi.h
  group sam/utils/cmsis/sam4c/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4c/include/pio/: pio_sam4c32e.h pio_sam4c4c.h pio_sam4c16c.h pio_sam4c8c.h pio_sam4c32c.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group sam/boards/atpl250amb
    ../../../../../../../../sam/boards/atpl250amb/: init.c led.h atpl250amb.h
  group common/services/sleepmgr
    ../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/sam4c
    ../../../../../../../../common/services/clock/sam4c/: sysclk.c genclk.h pll.h osc.h sysclk.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../../../freertos/freertos-7.3.0/source/: queue.c list.c timers.c FreeRTOS_CLI.c tasks.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam
    ../../../../../../../freertos/freertos-7.3.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../../../freertos/freertos-7.3.0/source/include/: list.h projdefs.h portable.h FreeRTOS.h FreeRTOS_CLI.h timers.h croutine.h queue.h task.h semphr.h StackMacros.h mpu_wrappers.h
  group thirdparty/g3/phy/atpl250/source_multiband
    ../../../../source_multiband/: atpl250_channel_estimation_as.S atpl250_sampling_error_estimation.c atpl250_fch.c atpl250_mod_demod.c atpl250_demodulator.S atpl250_aux_func_as.S atpl250_channel_estimation.c atpl250_reed_solomon.c atpl250_ber.c atpl250_hw_init.c atpl250_txrx_chain.c atpl250_jump_ram.c atpl250_carrier_mapping.c atpl250_sampling_error_estimation_as.S atpl250.c atpl250_modulator.S
  group thirdparty/g3/phy/atpl250/apps/phy_tester_tool
    ../../: phy_embedded_example.c
  group thirdparty/g3/phy/atpl250/apps/phy_tester_tool/sam4c16c_atpl250amb_multiband
    ../: conf_oss.h conf_project.h conf_clock.h conf_uart_serial.h conf_busart_if.h conf_buart_if.h conf_usi.h conf_sleepmgr.h conf_pplc_if.h conf_board.h FreeRTOSConfig.h conf_hal.h
  group thirdparty/g3/phy/atpl250/apps/phy_tester_tool/sam4c16c_atpl250amb_multiband/iar
    ./: asf.h
  group thirdparty/g3/phy/atpl250/addons/serial_if
    ../../../../addons/serial_if/: serial_if.c serial_if.h
  group thirdparty/g3/phy/atpl250/module_config
    ../../../../module_config/: conf_fw.h conf_hw.h
  group thirdparty/g3/phy/atpl250/include_multiband
    ../../../../include_multiband/: atpl250_txrx_chain.h atpl250_fch.h atpl250_version.h atpl250_reg.h atpl250_hw_init.h atpl250_channel_and_sfo_estimation_params.h atpl250_mod_demod.h atpl250_carrier_mapping.h atpl250_reed_solomon.h atpl250_channel_estimation.h atpl250.h atpl250_sampling_error_estimation.h atpl250_jump_ram.h atpl250_ber.h atpl250_common.h
  group thirdparty/g3/oss
    ../../../../../../oss/: oss_if.c oss_if.h
  group thirdparty/g3/hal
    ../../../../../../hal/: hal.h
  group thirdparty/g3/hal/SAM
    ../../../../../../hal/SAM/: hal.c hal.h
