# Keil uVision project apps_phy_tester_tool_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.0
  cpu: IROM(0x00400000,0x00200000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: apps_template_app
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: __G3_STACK__ __FREERTOS__ __SAME70Q21__ ARM_MATH_CM7=true BOARD=ATPL250ABN_V2
  c misc: --diag_suppress=66 --gnu
  c include: ..\..\..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\..\..\..\..\sam\services\plc\pcrc;..\..\..\..\..\..\..\..\sam\utils\fpu;..\..\..\..\addons\serial_if;..\..\..\..\..\..\..\..\common\services\ioport;..\..\..\..\..\..\..\freertos\freertos-7.3.0\source\include;..\..\..\..\..\..\..\..\sam\utils;..\..;..\..\..\..\..\..\..\..\common\boards;..\..\..\..\..\..\..\..\sam\utils\cmsis\same70\include;..\..\..\..\..\..\..\..\sam\drivers\aes;..\..\..\..\..\..\..\..\sam\boards;..\..\..\..\..\..\..\..\sam\services\plc\buart_if;..\..\..\..\..\..\..\..\sam\drivers\uart;..\..\..\..\..\..\..\..\sam\boards\atpl250abn_v2;..\..\..\..\..\..\..\..\sam\drivers\pmc;..\..\..\..\..\..\..\..\sam\drivers\sdramc;..\..\..\..\..\..\..\..\sam\services\plc\pplc_if\atpl250_multiband;..\..\..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\..\..\sam\drivers\gpbr;..\..\..\..\..\..\..\..\common\utils;..\..\..\..\..\..\..\..\sam\drivers\pio;..\..\..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\include_multiband;..\..\..\..\..\..\..\..\sam\drivers\mpu;..\..\..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\..\..\..\..\sam\drivers\supc;..\..\..\..\..\..\oss;..\..\..\..\..\..\..\..\common\services\clock;..\..\..\..\module_config;..\..\..\..\..\..\..\..\sam\drivers\trng;..\..\..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f;..\..\..\..\..\..\..\..\sam\services\plc\usi;..\..\..\..\..\..\..\..\common\services\gpio;..\..\..\..\..\..\..\..\sam\drivers\matrix;..\..\..\..\..\..\..\..\sam\utils\header_files;..\..\..\..\..\..;..\..\..\..\..\..\..\..\common\services\serial\sam_uart;..\..\..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\..\..\sam\services\plc\busart_if;..\..\..\..\..\..\..\..\sam\utils\cmsis\same70\source\templates;..\..\..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\..\..\..\sam\services\flash_efc;..\..\..\..\..\..\..\..\sam\drivers\xdmac;..\..\..\..\..\..\..\..\common\services\sleepmgr;..;..\..\..\..\..\..\..\..\sam\drivers\usart;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: sram.sct
  link misc: --diag_suppress=L6314
target flash (ARM-ADS)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.0
  cpu: as above
  output: uart
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAME70_XPLD __SAME70Q21__ flash TRACE_LEVEL=4
  c include: ..\..\;..\..\..\..\libraries\libchip;..\..\..\..\libraries\libchip\include;..\..\..\..\libraries\libchip\include\same70;..\..\..\..\libraries\libchip\include\cmsis\CMSIS\Include;..\..\..\..\libraries\libboard;..\..\..\..\libraries\libboard\include
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: flash.sct
  link misc: --diag_suppress=L6314
  group added to the first target's files
    ../../../../../../../../common/services/clock/same70/: sysclk.c
    ../../../../../../../../common/services/serial/: usart_serial.c
    ../../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
    ../../../../../../../../common/utils/stdio/: read.c write.c
    ../../../../../../../../sam/boards/atpl250abn_v2/: init.c low_level_init.c
    ../../../../../../../../sam/drivers/aes/: aes.c
    ../../../../../../../../sam/drivers/efc/: efc.c
    ../../../../../../../../sam/drivers/gpbr/: gpbr.c
    ../../../../../../../../sam/drivers/matrix/: matrix.c
    ../../../../../../../../sam/drivers/mpu/: mpu.c
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
    ../../../../../../../../sam/drivers/sdramc/: sdramc.c
    ../../../../../../../../sam/drivers/spi/: spi.c
    ../../../../../../../../sam/drivers/supc/: supc.c
    ../../../../../../../../sam/drivers/tc/: tc.c
    ../../../../../../../../sam/drivers/trng/: trng.c
    ../../../../../../../../sam/drivers/uart/: uart.c
    ../../../../../../../../sam/drivers/usart/: usart.c
    ../../../../../../../../sam/drivers/xdmac/: xdmac.c
    ../../../../../../../../sam/services/flash_efc/: flash_efc.c
    ../../../../../../../../sam/services/plc/buart_if/: buart_if.c
    ../../../../../../../../sam/services/plc/busart_if/: busart_if.c
    ../../../../../../../../sam/services/plc/pcrc/: pcrc.c
    ../../../../../../../../sam/services/plc/pplc_if/atpl250_multiband/: pplc_if.c
    ../../../../../../../../sam/services/plc/usi/: usi.c
    ../../../../../../hal/SAM/: hal.c
    ../../../../../../oss/: oss_if.c
    ../../../../addons/serial_if/: serial_if.c
    ../../../../source_multiband/: atpl250.c atpl250_aux_func_as.S atpl250_ber.c atpl250_carrier_mapping.c atpl250_channel_estimation.c atpl250_channel_estimation_as.S atpl250_demodulator.S atpl250_fch.c atpl250_hw_init.c atpl250_jump_ram.c atpl250_mod_demod.c atpl250_modulator.S atpl250_reed_solomon.c atpl250_sampling_error_estimation.c atpl250_sampling_error_estimation_as.S atpl250_txrx_chain.c
    ../../: phy_embedded_example.c
    ./: retarget.c startup_SAME70.s system_same70.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
