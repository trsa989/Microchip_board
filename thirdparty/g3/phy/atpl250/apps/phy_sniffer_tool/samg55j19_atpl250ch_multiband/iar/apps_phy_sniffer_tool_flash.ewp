# IAR project apps_phy_sniffer_tool_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __G3_STACK__; __FREERTOS__; BOARD=ATPL250CH; __SAMG55J19__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\..\..\sam\services\plc\pcrc; ..\..\..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\..\..\sam\services\plc\usi; ..\..\..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..; ..\..\..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\..\..\sam\services\plc\buart_if; ..\..\..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\..\..\..\sam\boards\atpl250ch; ..\..\..\..\..\..\..\..\sam\services\plc\pplc_if\atpl250_multiband; ..\..\..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\source\templates; ..\..\..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\include_multiband; ..\..\..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\include; ..\..\..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\..\oss; ..\..\..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\module_config; ..\..\..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f; ..\..\..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..; ..\..\..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\..\..\sam\services\plc\busart_if; ..; ..\..\..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\addons\sniffer_if; ..\..\..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_phy_sniffer_tool_flash.bin
  ILINK.IlinkOutputFile: apps_phy_sniffer_tool_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\..\sam\utils\linker_scripts\samg\samg55j19\iar\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/sleepmgr
    ../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: sysclk.h pll.h genclk.h osc.h
  group common/services/clock/samg
    ../../../../../../../../common/services/clock/samg/: sysclk.c osc.h sysclk.h pll.h genclk.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../../../freertos/freertos-7.3.0/source/: queue.c list.c timers.c tasks.c FreeRTOS_CLI.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f
    ../../../../../../../freertos/freertos-7.3.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../../../freertos/freertos-7.3.0/source/include/: list.h portable.h queue.h projdefs.h FreeRTOS.h FreeRTOS_CLI.h mpu_wrappers.h semphr.h timers.h croutine.h task.h StackMacros.h
  group thirdparty/g3/phy/atpl250/source_multiband
    ../../../../source_multiband/: atpl250_channel_estimation_as.S atpl250_sampling_error_estimation.c atpl250_fch.c atpl250_mod_demod.c atpl250_demodulator.S atpl250_aux_func_as.S atpl250_channel_estimation.c atpl250_reed_solomon.c atpl250_ber.c atpl250_hw_init.c atpl250_txrx_chain.c atpl250_jump_ram.c atpl250_carrier_mapping.c atpl250.c atpl250_modulator.S atpl250_sampling_error_estimation_as.S
  group thirdparty/g3/phy/atpl250/apps/phy_sniffer_tool
    ../../: phy_sniffer_tool.c
  group thirdparty/g3/phy/atpl250/apps/phy_sniffer_tool/samg55j19_atpl250ch_multiband
    ../: conf_busart_if.h conf_pplc_if.h conf_project.h conf_clock.h conf_buart_if.h conf_usb.h conf_usi.h conf_sleepmgr.h conf_board.h conf_hal.h FreeRTOSConfig.h conf_oss.h conf_uart_serial.h
  group thirdparty/g3/phy/atpl250/apps/phy_sniffer_tool/samg55j19_atpl250ch_multiband/iar
    ./: asf.h
  group thirdparty/g3/phy/atpl250/addons/sniffer_if
    ../../../../addons/sniffer_if/: sniffer_if.c sniffer_if.h
  group thirdparty/g3/phy/atpl250/module_config
    ../../../../module_config/: conf_fw.h conf_hw.h
  group thirdparty/g3/phy/atpl250/include_multiband
    ../../../../include_multiband/: atpl250_txrx_chain.h atpl250_fch.h atpl250_version.h atpl250_reg.h atpl250_channel_and_sfo_estimation_params.h atpl250_mod_demod.h atpl250_carrier_mapping.h atpl250_reed_solomon.h atpl250_hw_init.h atpl250_channel_estimation.h atpl250.h atpl250_sampling_error_estimation.h atpl250_ber.h atpl250_common.h atpl250_jump_ram.h
  group thirdparty/g3/oss
    ../../../../../../oss/: oss_if.c oss_if.h
  group thirdparty/g3/hal
    ../../../../../../hal/: hal.h
  group thirdparty/g3/hal/SAM
    ../../../../../../hal/SAM/: hal.c hal.h
  group sam/services/plc/busart_if
    ../../../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/plc/buart_if
    ../../../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/pplc_if/atpl250_multiband
    ../../../../../../../../sam/services/plc/pplc_if/atpl250_multiband/: pplc_if.c pplc_if.h
  group sam/services/plc/pcrc
    ../../../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/usi
    ../../../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/flash_efc
    ../../../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/drivers/adc
    ../../../../../../../../sam/drivers/adc/: adc2.c adc2.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/gpbr
    ../../../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/efc
    ../../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/supc
    ../../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/flexcom
    ../../../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../../../../sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../../../../sam/utils/cmsis/samg/samg55/include/: samg55j18.h samg55g18.h samg55g19.h samg55n19.h samg55.h system_samg55.h samg55j19.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../../../../sam/utils/cmsis/samg/samg55/include/pio/: samg55g19.h samg55n19.h samg55j19.h samg55g18.h samg55j18.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../../../../sam/utils/cmsis/samg/samg55/include/instance/: twi5.h pdmic1.h usart2.h usart0.h pdmic0.h rtc.h udp.h usart7.h spi1.h wdt.h supc.h usart5.h usart3.h uhp.h i2sc0.h usart1.h piob.h spi5.h efc.h spi7.h tc0.h twi7.h flexcom7.h mem2mem.h matrix.h rtt.h twi3.h crccu.h twi6.h rstc.h twi1.h spi6.h spi2.h pmc.h spi3.h i2sc1.h chipid.h flexcom3.h flexcom0.h flexcom1.h flexcom6.h tc1.h flexcom4.h twi2.h spi0.h twi0.h pioa.h cmcc.h adc.h usart6.h usart4.h gpbr.h spi4.h flexcom2.h twi4.h flexcom5.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../../../../sam/utils/cmsis/samg/samg55/include/component/: uhp.h rtc.h pmc.h pdmic.h supc.h matrix.h efc.h rtt.h cmcc.h flexcom.h rstc.h i2sc.h crccu.h pio.h mem2mem.h pdc.h udp.h gpbr.h usart.h spi.h chipid.h twi.h tc.h wdt.h adc.h
  group sam/utils/fpu
    ../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group sam/boards/atpl250ch
    ../../../../../../../../sam/boards/atpl250ch/: init.c led.h atpl250ch.h
