# IAR project apps_phy_sniffer_tool_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21 Atmel ATSAME70Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __G3_STACK__; __FREERTOS__; __SAME70Q21__; ARM_MATH_CM7=true; BOARD=ATPL250ABN_V2
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\..\..\sam\services\plc\pcrc; ..\..\..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\..\..\sam\services\plc\usi; ..\..\..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..; ..\..\..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\..\..\sam\utils\cmsis\same70\include; ..\..\..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\..\..\sam\services\plc\buart_if; ..\..\..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\..\..\sam\boards\atpl250abn_v2; ..\..\..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\..\..\..\sam\drivers\sdramc; ..\..\..\..\..\..\..\..\sam\services\plc\pplc_if\atpl250_multiband; ..\..\..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\include_multiband; ..\..\..\..\..\..\..\..\sam\drivers\mpu; ..\..\..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\..\oss; ..\..\..\..\..\..\..\..\common\services\clock; ..\..\..\..\module_config; ..\..\..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f; ..\..\..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\..\..\sam\drivers\matrix; ..\..\..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..; ..\..\..\..\..\..\..\..\common\services\serial\sam_uart; ..; ..\..\..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\..\..\sam\services\plc\busart_if; ..\..\..\..\..\..\..\..\sam\utils\cmsis\same70\source\templates; ..\..\..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\..\..\sam\drivers\xdmac; ..\..\..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\addons\sniffer_if; ..\..\..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_phy_sniffer_tool_flash.bin
  ILINK.IlinkOutputFile: apps_phy_sniffer_tool_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\..\sam\utils\linker_scripts\same70\same70q21\iar\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/sleepmgr
    ../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: osc.h sysclk.h pll.h genclk.h
  group common/services/clock/same70
    ../../../../../../../../common/services/clock/same70/: sysclk.c pll.h osc.h genclk.h sysclk.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../../../freertos/freertos-7.3.0/source/: queue.c list.c timers.c tasks.c FreeRTOS_CLI.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f
    ../../../../../../../freertos/freertos-7.3.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../../../freertos/freertos-7.3.0/source/include/: croutine.h projdefs.h FreeRTOS.h FreeRTOS_CLI.h semphr.h mpu_wrappers.h queue.h portable.h timers.h list.h task.h StackMacros.h
  group thirdparty/g3/phy/atpl250/source_multiband
    ../../../../source_multiband/: atpl250_sampling_error_estimation.c atpl250_fch.c atpl250_mod_demod.c atpl250_demodulator.S atpl250_aux_func_as.S atpl250_channel_estimation_as.S atpl250_channel_estimation.c atpl250_reed_solomon.c atpl250_ber.c atpl250_hw_init.c atpl250_jump_ram.c atpl250_carrier_mapping.c atpl250_txrx_chain.c atpl250.c atpl250_modulator.S atpl250_sampling_error_estimation_as.S
  group thirdparty/g3/phy/atpl250/apps/phy_sniffer_tool
    ../../: phy_sniffer_tool.c
  group thirdparty/g3/phy/atpl250/apps/phy_sniffer_tool/same70q21_atpl250abn_multiband
    ../: conf_sleepmgr.h conf_oss.h conf_project.h conf_busart_if.h conf_buart_if.h conf_pplc_if.h conf_board.h conf_clock.h FreeRTOSConfig.h conf_hal.h conf_uart_serial.h conf_usi.h
  group thirdparty/g3/phy/atpl250/apps/phy_sniffer_tool/same70q21_atpl250abn_multiband/iar
    ./: asf.h
  group thirdparty/g3/phy/atpl250/addons/sniffer_if
    ../../../../addons/sniffer_if/: sniffer_if.c sniffer_if.h
  group thirdparty/g3/phy/atpl250/include_multiband
    ../../../../include_multiband/: atpl250_fch.h atpl250_txrx_chain.h atpl250_version.h atpl250_hw_init.h atpl250_channel_and_sfo_estimation_params.h atpl250_mod_demod.h atpl250_carrier_mapping.h atpl250_reed_solomon.h atpl250_channel_estimation.h atpl250.h atpl250_sampling_error_estimation.h atpl250_jump_ram.h atpl250_ber.h atpl250_common.h atpl250_reg.h
  group thirdparty/g3/phy/atpl250/module_config
    ../../../../module_config/: conf_fw.h conf_hw.h
  group thirdparty/g3/oss
    ../../../../../../oss/: oss_if.c oss_if.h
  group thirdparty/g3/hal
    ../../../../../../hal/: hal.h
  group thirdparty/g3/hal/SAM
    ../../../../../../hal/SAM/: hal.c hal.h
  group sam/services/plc/busart_if
    ../../../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/plc/buart_if
    ../../../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/pplc_if/atpl250_multiband
    ../../../../../../../../sam/services/plc/pplc_if/atpl250_multiband/: pplc_if.c pplc_if.h
  group sam/services/plc/pcrc
    ../../../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/usi
    ../../../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/flash_efc
    ../../../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/boards/atpl250abn_v2
    ../../../../../../../../sam/boards/atpl250abn_v2/: init.c low_level_init.c led.h atpl250abn_v2.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/mpu
    ../../../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/matrix
    ../../../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/gpbr
    ../../../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/trng
    ../../../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/efc
    ../../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/xdmac
    ../../../../../../../../sam/drivers/xdmac/: xdmac.c xdmac.h
  group sam/drivers/supc
    ../../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/sdramc
    ../../../../../../../../sam/drivers/sdramc/: sdramc.c sdramc.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../../../sam/utils/cmsis/same70/include/: same70n20b.h same70q19b.h same70j19b.h same70j20.h same70q21.h same70.h same70j19.h same70j20b.h same70n19b.h same70n21.h same70q19.h same70q20.h same70n21b.h same70j21b.h same70j21.h same70n19.h same70n20.h same70q21b.h same70q20b.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../../../sam/utils/cmsis/same70/include/component/: pio.h afec.h gmac.h efc.h utmi.h rtc.h uart.h aes.h xdmac.h rstc.h acc.h trng.h qspi.h gpbr.h dacc.h usart.h wdt.h chipid.h supc.h pmc.h sdramc.h twihs.h matrix.h ssc.h i2sc.h hsmci.h usbhs.h rswdt.h icm.h isi.h spi.h smc.h pwm.h tc.h rtt.h mcan.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../../../sam/utils/cmsis/same70/include/instance/: utmi.h qspi.h gpbr.h dacc.h usart1.h sdramc.h acc.h pioc.h i2sc0.h trng.h mcan0.h uart3.h efc.h gmac.h pwm1.h pioa.h tc3.h matrix.h tc1.h smc.h isi.h usart0.h piod.h usbhs.h twihs1.h spi1.h chipid.h spi0.h hsmci.h tc2.h icm.h pwm0.h tc0.h i2sc1.h twihs2.h xdmac.h afec1.h mcan1.h aes.h twihs0.h uart4.h rtt.h rswdt.h rtc.h ssc.h usart2.h pioe.h supc.h uart1.h uart2.h piob.h pmc.h uart0.h wdt.h afec0.h rstc.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../../../sam/utils/cmsis/same70/include/pio/: same70j19.h same70q20b.h same70n20.h same70j21.h same70q21.h same70j19b.h same70n20b.h same70n21.h same70n19.h same70q20.h same70n19b.h same70q19b.h same70q19.h same70q21b.h same70n21b.h same70j20.h same70j20b.h same70j21b.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group sam/utils/fpu
    ../../../../../../../../sam/utils/fpu/: fpu.h
