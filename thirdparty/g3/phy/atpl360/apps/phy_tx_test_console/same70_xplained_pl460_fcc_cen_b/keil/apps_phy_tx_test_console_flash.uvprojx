# Keil uVision project apps_phy_tx_test_console_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.0
  cpu: IROM(0x00400000,0x00200000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: apps_template_app
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD=SAME70_XPLAINED UDD_ENABLE __SAME70Q21B__ ARM_MATH_CM7=true
  c misc: --diag_suppress=66 --gnu
  c include: ..\..\..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\coup_tx_config\coup_params;..\..\..\..\..\..\..\..\sam\utils\fpu;..\..\..\..\..\..\..\..\common\services\ioport;..\..\..\..\..\..\..\..\common\services\usb\class\cdc\device;..\..\..\..\..\..\..\..\sam\utils;..\..\..\..\..\..\..\..\common\services\usb;..\..\..\..\coup_tx_config;..\..\..\..\..\..\..\..\sam\services\plc\usb_wrp;..\..\..\..\..\..\..\..\common\boards;..;..\..\..\..\..\..\..\..\sam\utils\cmsis\same70\include;..\..\..\..\..\..\..\..\sam\drivers\wdt;..\..\..\..\..\..\..\..\common\services\usb\udc;..\..\..\..\..\..\..\..\common\components\plc\atpl360;..\..\..\..\..\..\..\..\sam\boards;..\..\..\..\..\..\..\..\sam\drivers\uart;..\..\..\..\..\..\..\..\sam\drivers\afec;..\..\..\..\..\..\..\..\sam\drivers\pmc;..\..;..\..\..\..\..\..\..\..\sam\boards\same70_xplained;..\..\..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\..\..\sam\drivers\gpbr;..\..\..\..\..\..\..\..\common\utils;..\..\..\..\..\..\..\..\common\services\delay;..\..\..\..\..\..\..\..\common\services\usb\class\cdc;..\..\..\..\..\..\..\..\sam\drivers\pio;..\..\..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\..\..\..\..\sam\drivers\usbhs;..\..\..\..\..\..\..\..\sam\drivers\mpu;..\..\..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\..\..\..\..\common\services\clock;..\..\..\..\..\..\..\..\common\components\plc\atpl360\G3;..\..\..\..\..\..\..\..\sam\drivers\trng;..\..\..\..\..\..\..\..\common\services\gpio;..\..\..\..\coup_tx_config\coup_conf\pl460_fcc_cen_b;..\..\..\..\..\..\..\..\sam\utils\header_files;..\..\..\..\..\..\..\..\common\services\serial\sam_uart;..\..\..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360;..\..\..\..\..\..\..\..\sam\utils\cmsis\same70\source\templates;..\..\..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\..\..\..\sam\drivers\usart;..\..\..\..\..\..\..\..\sam\services\flash_efc;..\..\..\..\..\..\..\..\sam\drivers\xdmac;..\..\..\..\..\..\..\..\common\services\sleepmgr;..\..\..\..\..\..\..\..\common\utils\stdio\stdio_udc;..\..\..\..\..\..\..\..\sam\drivers\rstc;..\..\..\..\coup_tx_config\pl360_wrp\g3_phy;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: sram.sct
  link misc: --diag_suppress=L6314
target flash (ARM-ADS)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.0
  cpu: as above
  output: uart
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAME70_XPLD __SAME70Q21__ flash TRACE_LEVEL=4
  c include: ..\..\;..\..\..\..\libraries\libchip;..\..\..\..\libraries\libchip\include;..\..\..\..\libraries\libchip\include\same70;..\..\..\..\libraries\libchip\include\cmsis\CMSIS\Include;..\..\..\..\libraries\libboard;..\..\..\..\libraries\libboard\include
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: flash.sct
  link misc: --diag_suppress=L6314
  group added to the first target's files
    ../../../../../../../../common/components/plc/atpl360/G3/: atpl360_IB_db.c atpl360_comm.c
    ../../../../../../../../common/components/plc/atpl360/: atpl360.c atpl360_IB.c atpl360_boot.c atpl360_hal_spi.c
    ../../../../../../../../common/services/clock/same70/: sysclk.c
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c
    ../../../../../../../../common/services/serial/: usart_serial.c
    ../../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
    ../../../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
    ../../../../../../../../common/services/usb/udc/: udc.c
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
    ../../../../../../../../common/utils/stdio/: read.c write.c
    ../../../../../../../../sam/boards/same70_xplained/: init.c
    ../../../../../../../../sam/drivers/afec/: afec.c
    ../../../../../../../../sam/drivers/efc/: efc.c
    ../../../../../../../../sam/drivers/gpbr/: gpbr.c
    ../../../../../../../../sam/drivers/mpu/: mpu.c
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
    ../../../../../../../../sam/drivers/rstc/: rstc.c
    ../../../../../../../../sam/drivers/spi/: spi.c
    ../../../../../../../../sam/drivers/tc/: tc.c
    ../../../../../../../../sam/drivers/trng/: trng.c
    ../../../../../../../../sam/drivers/uart/: uart.c
    ../../../../../../../../sam/drivers/usart/: usart.c
    ../../../../../../../../sam/drivers/usbhs/: usbhs_device.c
    ../../../../../../../../sam/drivers/wdt/: wdt.c
    ../../../../../../../../sam/drivers/xdmac/: xdmac.c
    ../../../../../../../../sam/services/flash_efc/: flash_efc.c
    ../../../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c
    ../../../../../../../../sam/services/plc/usb_wrp/: usb_wrp.c
    ../../../../coup_tx_config/: coup_tx_config.c
    ../../: phy_embedded_example.c phy_tx_test_console.c
    ./: atpl_bin_multi.S retarget.c startup_SAME70.s system_same70.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
