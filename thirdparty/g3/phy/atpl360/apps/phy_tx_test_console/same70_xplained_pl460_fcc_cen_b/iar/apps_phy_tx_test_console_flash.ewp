# IAR project apps_phy_tx_test_console_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21 Atmel ATSAME70Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=SAME70_XPLAINED; UDD_ENABLE; __SAME70Q21B__; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\coup_tx_config\coup_params; ..\..\..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\..\..\common\services\usb\class\cdc\device; ..\..\..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\..\..\common\services\usb; ..\..\..\..\coup_tx_config; ..\..\..\..\..\..\..\..\sam\services\plc\usb_wrp; ..\..\..\..\..\..\..\..\common\boards; ..; ..\..\..\..\..\..\..\..\sam\utils\cmsis\same70\include; ..\..\..\..\..\..\..\..\sam\drivers\wdt; ..\..\..\..\..\..\..\..\common\services\usb\udc; ..\..\..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\..\..\sam\drivers\afec; ..\..\..\..\..\..\..\..\sam\drivers\pmc; ..\..; ..\..\..\..\..\..\..\..\sam\boards\same70_xplained; ..\..\..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\..\..\common\services\usb\class\cdc; ..\..\..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\..\..\sam\drivers\usbhs; ..\..\..\..\..\..\..\..\sam\drivers\mpu; ..\..\..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\G3; ..\..\..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\..\..\..\..\common\services\gpio; ..\..\..\..\coup_tx_config\coup_conf\pl460_fcc_cen_b; ..\..\..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360; ..\..\..\..\..\..\..\..\sam\utils\cmsis\same70\source\templates; ..\..\..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\..\..\sam\drivers\usart; ..\..\..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\..\..\sam\drivers\xdmac; ..\..\..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\..\..\common\utils\stdio\stdio_udc; ..\..\..\..\..\..\..\..\sam\drivers\rstc; ..\..\..\..\coup_tx_config\pl360_wrp\g3_phy; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_phy_tx_test_console_flash.bin
  ILINK.IlinkOutputFile: apps_phy_tx_test_console_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\..\sam\utils\linker_scripts\same70\same70q21\iar\flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\..\..\atpl\bin\ATPL360B_G3_CENB.bin,atpl_bin_cenb,P_atpl_bin_cenb,8; --image_input ..\..\..\..\..\..\..\..\atpl\bin\ATPL360B_G3_FCC.bin,atpl_bin_fcc,P_atpl_bin_fcc,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/xdmac
    ../../../../../../../../sam/drivers/xdmac/: xdmac.c xdmac.h
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/mpu
    ../../../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/rstc
    ../../../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/efc
    ../../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/trng
    ../../../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/gpbr
    ../../../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/afec
    ../../../../../../../../sam/drivers/afec/: afec.c afec.h
  group sam/drivers/usbhs
    ../../../../../../../../sam/drivers/usbhs/: usbhs_device.c usbhs_otg.h usbhs_device.h
  group sam/boards/same70_xplained
    ../../../../../../../../sam/boards/same70_xplained/: init.c same70_xplained.h led.h
  group sam/utils
    ../../../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../../../sam/utils/cmsis/same70/include/: same70n20b.h same70q19b.h same70j19b.h same70n20.h same70j20.h same70n21b.h same70.h same70n21.h same70j19.h same70q19.h same70q20.h same70j21b.h same70j21.h same70n19.h same70j20b.h same70q21b.h same70q20b.h same70n19b.h same70q21.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../../../sam/utils/cmsis/same70/include/instance/: utmi.h supc.h qspi.h gpbr.h dacc.h usart1.h sdramc.h pioc.h i2sc0.h trng.h mcan0.h uart3.h efc.h gmac.h xdmac.h pioa.h tc3.h matrix.h tc1.h smc.h isi.h usart0.h icm.h usbhs.h twihs1.h spi1.h chipid.h uart1.h spi0.h pwm1.h hsmci.h tc2.h pwm0.h tc0.h twihs2.h afec1.h mcan1.h aes.h twihs0.h uart4.h rtt.h usart2.h acc.h rswdt.h rtc.h ssc.h piod.h pioe.h uart2.h i2sc1.h piob.h pmc.h uart0.h wdt.h afec0.h rstc.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../../../sam/utils/cmsis/same70/include/component/: afec.h gmac.h utmi.h aes.h spi.h rtc.h wdt.h uart.h xdmac.h rstc.h pio.h acc.h qspi.h gpbr.h dacc.h usart.h efc.h chipid.h supc.h pmc.h sdramc.h mcan.h twihs.h matrix.h ssc.h i2sc.h hsmci.h usbhs.h rswdt.h icm.h isi.h smc.h pwm.h trng.h tc.h rtt.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../../../sam/utils/cmsis/same70/include/pio/: same70j19.h same70q20b.h same70n20.h same70j21.h same70q21.h same70j19b.h same70n20b.h same70n21.h same70n19.h same70q20.h same70n19b.h same70q19b.h same70q19.h same70q21b.h same70n21b.h same70j20.h same70j20b.h same70j21b.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group sam/services/plc/pplc_if/atpl360
    ../../../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c pplc_if.h
  group sam/services/plc/usb_wrp
    ../../../../../../../../sam/services/plc/usb_wrp/: usb_wrp.c usb_wrp.h
  group sam/services/flash_efc
    ../../../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group common/components/plc/atpl360
    ../../../../../../../../common/components/plc/atpl360/: atpl360.c atpl360_boot.c atpl360_IB.c atpl360_hal_spi.c atpl360_boot.h atpl360_hal_spi.h atpl360.h atpl360_IB_db_api.h atpl360_exception.h atpl360_IB.h
  group common/components/plc/atpl360/G3
    ../../../../../../../../common/components/plc/atpl360/G3/: atpl360_IB_db.c atpl360_comm.c general_defs.h atpl360_comm.h atpl360_IB_db.h
  group common/services/usb
    ../../../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc.h udi_cdc_conf.h
  group common/services/usb/udc
    ../../../../../../../../common/services/usb/udc/: udc.c udc_desc.h udc.h udi.h udd.h
  group common/services/sleepmgr
    ../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: sysclk.h pll.h genclk.h osc.h
  group common/services/clock/same70
    ../../../../../../../../common/services/clock/same70/: sysclk.c pll.h osc.h genclk.h sysclk.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_udc
    ../../../../../../../../common/utils/stdio/stdio_udc/: stdio_udc.h
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group thirdparty/g3/phy/atpl360/apps/phy_tx_test_console
    ../../: phy_embedded_example.c phy_tx_test_console.c phy_embedded_example.h
  group thirdparty/g3/phy/atpl360/apps/phy_tx_test_console/same70_xplained_pl460_fcc_cen_b
    ../: conf_project.h conf_usb.h conf_pplc_if.h conf_board.h conf_clock.h conf_sleepmgr.h conf_atpl360.h conf_uart_serial.h
  group thirdparty/g3/phy/atpl360/apps/phy_tx_test_console/same70_xplained_pl460_fcc_cen_b/iar
    ./: asf.h
  group thirdparty/g3/phy/atpl360/coup_tx_config
    ../../../../coup_tx_config/: coup_tx_config.c coup_tx_config.h coup_defs.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_params
    ../../../../coup_tx_config/coup_params/: pl460_plcoup014_cen_b.h pl460_sb_fcc.h pl460_1_5b_fcc.h plcoup014_cen_b.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/pl360_wrp/g3_phy
    ../../../../coup_tx_config/pl360_wrp/g3_phy/: coup_pl360_wrp.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_conf/pl460_fcc_cen_b
    ../../../../coup_tx_config/coup_conf/pl460_fcc_cen_b/: coup_conf.h
