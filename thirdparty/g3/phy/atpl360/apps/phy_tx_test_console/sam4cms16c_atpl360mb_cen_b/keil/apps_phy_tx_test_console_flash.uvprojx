# Keil uVision project apps_phy_tx_test_console_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAM4CMS16C:CM4_P0 Atmel
  pack: Keil.SAM4_DFP.1.6.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x01000000,0x100000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: apps_template_app
  c flags: Optim=3 oTime=1 uC99=1 wLevel=2
  c define: BOARD=ATPL360MB __SAM4CMS16C_0__ ARM_MATH_CM4=true
  c misc: --diag_suppress=66
  c include: ..\..\..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\coup_tx_config\coup_params;..\..\..\..\..\..\..\..\sam\drivers\wdt;..\..\..\..\..\..\..\..\common\services\ioport;..\..\..\..\..\..\..\..\sam\components\display\c0216CiZ;..\..\..\..\..\..\..\..\sam\utils;..\..\..\..\coup_tx_config;..\..\..\..\..\..\..\..\common\boards;..\..\..\..\..\..\..\..\common\components\plc\atpl360;..\..\..\..\..\..\..\..\sam\drivers\pdc;..\..\..\..\..\..\..\..\sam\boards;..\..\..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\..\..\..\..\sam\drivers\uart;..\..\..\..\..\..\..\..\sam\drivers\pmc;..\..\..\..\..\..\..\..\sam\boards\atpl360mb;..\..;..\..\..\..\..\..\..\..\common\services\twi;..\..\..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\..\..\sam\drivers\gpbr;..\..\..\..\..\..\..\..\common\utils;..\..\..\..\..\..\..\..\common\services\delay;..\..\..\..\..\..\..\..\sam\drivers\pio;..\..\..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\..\..\..\..\sam\drivers\adc;..\..\..\..\..\..\..\..\sam\drivers\supc;..;..\..\..\..\..\..\..\..\common\services\clock;..\..\..\..\..\..\..\..\common\components\plc\atpl360\G3;..\..\..\..\..\..\..\..\sam\drivers\trng;..\..\..\..\..\..\..\..\sam\utils\cmsis\sam4cm\source\templates;..\..\..\..\coup_tx_config\coup_conf\pl360_cen_b;..\..\..\..\..\..\..\..\common\services\gpio;..\..\..\..\..\..\..\..\sam\drivers\twi;..\..\..\..\..\..\..\..\sam\utils\header_files;..\..\..\..\..\..\..\..\common\services\serial\sam_uart;..\..\..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\..\..\sam\utils\cmsis\sam4cm\include;..\..\..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360;..\..\..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\..\..\..\sam\drivers\rstc;..\..\..\..\..\..\..\..\sam\services\flash_efc;..\..\..\..\..\..\..\..\sam\drivers\usart;..\..\..\..\coup_tx_config\pl360_wrp\g3_phy;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x1000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\sam4c16c.sct
  group Startup
    ./: startup_SAM4CM.s retarget.c system_sam4cm.c atpl_bin.S
  group sam_drivers_supc
    ../../../../../../../../sam/drivers/supc/: supc.c
  group sam_drivers_wdt
    ../../../../../../../../sam/drivers/wdt/: wdt.c
  group sam_drivers_usart
    ../../../../../../../../sam/drivers/usart/: usart.c
  group sam_drivers_pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c
  group sam_drivers_rstc
    ../../../../../../../../sam/drivers/rstc/: rstc.c
  group sam_drivers_tc
    ../../../../../../../../sam/drivers/tc/: tc.c
  group sam_drivers_pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam_drivers_efc
    ../../../../../../../../sam/drivers/efc/: efc.c
  group sam_drivers_spi
    ../../../../../../../../sam/drivers/spi/: spi.c
  group sam_drivers_trng
    ../../../../../../../../sam/drivers/trng/: trng.c
  group sam_drivers_pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam_drivers_uart
    ../../../../../../../../sam/drivers/uart/: uart.c
  group sam_drivers_twi
    ../../../../../../../../sam/drivers/twi/: twi.c
  group sam_drivers_gpbr
    ../../../../../../../../sam/drivers/gpbr/: gpbr.c
  group sam_drivers_adc
    ../../../../../../../../sam/drivers/adc/: adc.c adc_sam3u.c
  group sam_boards_atpl360mb
    ../../../../../../../../sam/boards/atpl360mb/: init.c
  group sam_components_display_c0216CiZ
    ../../../../../../../../sam/components/display/c0216CiZ/: c0216CiZ.c
  group sam_services_plc_pplc_if_atpl360
    ../../../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c
  group sam_services_flash_efc
    ../../../../../../../../sam/services/flash_efc/: flash_efc.c
  group common_components_plc_atpl360
    ../../../../../../../../common/components/plc/atpl360/: atpl360.c atpl360_boot.c
    ../../../../../../../../common/components/plc/atpl360/G3/: atpl360_IB_db.c atpl360_comm.c
  group common_components_plc_atpl360
    ../../../../../../../../common/components/plc/atpl360/: atpl360_IB.c atpl360_hal_spi.c
  group common_utils_stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common_utils_interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common_services_clock_sam4cm
    ../../../../../../../../common/services/clock/sam4cm/: sysclk.c
  group common_services_serial
    ../../../../../../../../common/services/serial/: usart_serial.c
  group common_services_delay_sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c
  group thirdparty_g3_phy_atpl360_coup_tx_config
    ../../../../coup_tx_config/: coup_tx_config.c
  group thirdparty_g3_phy_atpl360_apps_phy_tx_test_console
    ../../: phy_embedded_example.c phy_tx_test_console.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
