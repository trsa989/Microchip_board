# Keil uVision project apps_phy_tester_hybrid_tool_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAMG55J19 Atmel
  pack: Keil.SAMG_DFP.1.1.0
  cpu: IROM(0x00400000,0x80000) IRAM(0x20000000,0x28000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: apps_template_app
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: __SAMG55J19__ BOARD=PL360G55CF_EK G3_HYBRID_PROFILE UDD_ENABLE ARM_MATH_CM4=true
  c misc: --diag_suppress=66 --gnu
  c include: ..\..\..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\..\..\..\..\sam\services\plc\pcrc;..\..\..\..\..\..\..\..\sam\utils\fpu;..\..\..\..\..\..\..\..\sam\services\plc\usi;..\..\..\..\..\..\..\..\common\components\plc\atpl360\addons\serial_if;..\..\..\..\..\..\..\..\common\services\ioport;..\..\..\..\..\..\..\..\common\services\usb\class\cdc\device;..\..\..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\include;..\..\..\..\..\..\..\..\sam\utils;..\..\..\..\..\..\..\..\common\services\usb;..\..\..\..\coup_tx_config;..\..\..\..\..\..\..\..\sam\services\plc\usb_wrp;..\..\..\..\coup_tx_config\coup_params;..\..\..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\..\..\..\..\sam\drivers\wdt;..\..\..\..\..\..\..\..\common\services\usb\udc;..\..\..\..\..\..\..\..\common\components\plc\atpl360;..\..\..\..\..\..\..\..\sam\drivers\pdc;..\..\..\..\..\..\..\..\sam\boards;..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_irq;..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_pll;..\..\..\..\..\..\..\..\sam\services\plc\buart_if;..\..\..\..\..\..\..\..\sam\drivers\pmc;..\..\..\..\..\..\..\..\sam\boards\pl360g55cf_ek;..\..\..\..\coup_tx_config\coup_conf\pl360_cen_a_fcc;..\..\..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\source\templates;..\..\..\..\..\..\..\..\common\components\rf\at86rf215\addons;..\..;..\..\..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\..\..\common\utils;..\..\..\..\..\..\..\..\common\services\delay;..\..\..\..\..\..\..\..\common\services\usb\class\cdc;..\..\..\..\..\..\..\..\sam\drivers\pio;..\..\..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\..\..\..\..\common\boards;..\..\..\..\..\..\..\..\common\components\rf\at86rf215;..\..\..\..\..\..\..\..\sam\services\timer_1us;..\..\..\..\..\..\..\..\sam\drivers\adc;..\..\..\..\..\..\..\..\sam\drivers\supc;..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_tx_rx;..\..\..\..\..\..\..\..\sam\services\plc\busart_if;..\..\..\..\..\..\..\..\common\services\clock;..\..\..\..\..\..\..\..\sam\drivers\flexcom;..\..\..\..\..\..\..\..\common\components\plc\atpl360\G3;..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_fe;..\..\..\..\..\..\..\..\common\services\gpio;..\..\..\..\..\..\..\..\common\utils\stdio\stdio_udc;..\..\..\..\..\..\..\..\sam\drivers\matrix;..\..\..\..\..\..\..\..\sam\utils\header_files;..\..\..\..\..\..\..\..\common\services\serial\sam_uart;..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_common;..\..\..\..\..\..\..\..\sam\drivers\udp;..\..\..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360;..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_bbc;..;..\..\..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\..\..\..\sam\drivers\usart;..\..\..\..\..\..\..\..\common\services\sleepmgr;..\..\..\..\..\..\..\..\common\components\plc\atpl360\addons;..\..\..\..\..\..\..\..\sam\services\rf\prf_if\at86rf215;..\..\..\..\coup_tx_config\pl360_wrp\g3_phy;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x400000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\samg55j19.sct
  group Startup
    ./: startup_SAMG55.s retarget.c system_samg55.c atpl_bin_multi.S
  group common_components_rf_at86rf215
    ../../../../../../../../common/components/rf/at86rf215/: at86rf215.c
    ../../../../../../../../common/components/rf/at86rf215/rf215_bbc/: rf215_bbc.c
  group common_components_rf_at86rf215_rf215_common
    ../../../../../../../../common/components/rf/at86rf215/rf215_common/: rf215_trx_ctl.c rf215_spi.c
  group common_components_rf_at86rf215_rf215_irq
    ../../../../../../../../common/components/rf/at86rf215/rf215_irq/: rf215_irq.c
  group common_components_rf_at86rf215_rf215_tx_rx
    ../../../../../../../../common/components/rf/at86rf215/rf215_tx_rx/: rf215_rx.c rf215_tx.c
  group common_components_rf_at86rf215_rf215_pll
    ../../../../../../../../common/components/rf/at86rf215/rf215_pll/: rf215_pll.c
  group common_components_rf_at86rf215_rf215_fe
    ../../../../../../../../common/components/rf/at86rf215/rf215_fe/: rf215_fe.c
  group common_components_rf_at86rf215_addons_serial_if
    ../../../../../../../../common/components/rf/at86rf215/addons/serial_if/: rf215_serial_if.c
  group common_components_plc_atpl360_addons_serial_if
    ../../../../../../../../common/components/plc/atpl360/addons/serial_if/: serial_if.c serial_if_g3.c
  group common_components_plc_atpl360
    ../../../../../../../../common/components/plc/atpl360/: atpl360_boot.c atpl360.c
    ../../../../../../../../common/components/plc/atpl360/G3/: atpl360_IB_db.c atpl360_comm.c
  group common_components_plc_atpl360
    ../../../../../../../../common/components/plc/atpl360/: atpl360_IB.c atpl360_hal_spi.c
  group common_services_usb_class_cdc_device
    ../../../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common_services_usb_udc
    ../../../../../../../../common/services/usb/udc/: udc.c
  group common_services_sleepmgr_sam
    ../../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group common_services_clock_samg
    ../../../../../../../../common/services/clock/samg/: sysclk.c
  group common_services_serial
    ../../../../../../../../common/services/serial/: usart_serial.c
  group common_services_delay_sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c
  group common_utils_stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common_utils_interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group sam_services_plc_busart_if
    ../../../../../../../../sam/services/plc/busart_if/: busart_if.c
  group sam_services_plc_buart_if
    ../../../../../../../../sam/services/plc/buart_if/: buart_if.c
  group sam_services_plc_pplc_if_atpl360
    ../../../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c
  group sam_services_plc_pcrc
    ../../../../../../../../sam/services/plc/pcrc/: pcrc.c
  group sam_services_plc_usb_wrp
    ../../../../../../../../sam/services/plc/usb_wrp/: usb_wrp.c
  group sam_services_plc_usi
    ../../../../../../../../sam/services/plc/usi/: usi.c
  group sam_services_timer_1us
    ../../../../../../../../sam/services/timer_1us/: timer_1us.c
    ../../../../../../../../sam/services/timer_1us/hal_samg55/: timer_1us_hal.c
  group sam_services_rf_prf_if_at86rf215
    ../../../../../../../../sam/services/rf/prf_if/at86rf215/: prf_if.c
  group sam_drivers_wdt
    ../../../../../../../../sam/drivers/wdt/: wdt.c
  group sam_drivers_adc
    ../../../../../../../../sam/drivers/adc/: adc2.c
  group sam_drivers_usart
    ../../../../../../../../sam/drivers/usart/: usart.c
  group sam_drivers_pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c
  group sam_drivers_matrix
    ../../../../../../../../sam/drivers/matrix/: matrix.c
  group sam_drivers_tc
    ../../../../../../../../sam/drivers/tc/: tc.c
  group sam_drivers_pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam_drivers_flexcom
    ../../../../../../../../sam/drivers/flexcom/: flexcom.c
  group sam_drivers_efc
    ../../../../../../../../sam/drivers/efc/: efc.c
  group sam_drivers_spi
    ../../../../../../../../sam/drivers/spi/: spi.c
  group sam_drivers_supc
    ../../../../../../../../sam/drivers/supc/: supc.c
  group sam_drivers_pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam_drivers_udp
    ../../../../../../../../sam/drivers/udp/: udp_device.c
  group sam_boards_pl360g55cf_ek
    ../../../../../../../../sam/boards/pl360g55cf_ek/: init.c
  group thirdparty_g3_phy_atpl360_coup_tx_config
    ../../../../coup_tx_config/: coup_tx_config.c
  group thirdparty_g3_phy_atpl360_apps_phy_tester_hybrid_tool
    ../../: phy_embedded_example.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
