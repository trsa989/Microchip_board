# IAR project apps_phy_tester_hybrid_tool_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMG55J19__; BOARD=PL360G55CF_EK; G3_HYBRID_PROFILE; UDD_ENABLE; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\..\..\sam\services\plc\pcrc; ..\..\..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\..\..\sam\services\plc\usi; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\addons\serial_if; ..\..\..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\..\..\common\services\usb\class\cdc\device; ..\..\..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\include; ..\..\..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\..\..\common\services\usb; ..\..\..\..\coup_tx_config; ..\..\..\..\..\..\..\..\sam\services\plc\usb_wrp; ..\..\..\..\coup_tx_config\coup_params; ..\..\..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\..\..\sam\drivers\wdt; ..\..\..\..\..\..\..\..\common\services\usb\udc; ..\..\..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_irq; ..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_pll; ..\..\..\..\..\..\..\..\sam\services\plc\buart_if; ..\..\..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\..\..\..\sam\boards\pl360g55cf_ek; ..\..\..\..\coup_tx_config\coup_conf\pl360_cen_a_fcc; ..\..\..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\source\templates; ..\..\..\..\..\..\..\..\common\components\rf\at86rf215\addons; ..\..; ..\..\..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\..\..\common\services\usb\class\cdc; ..\..\..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\..\..\common\components\rf\at86rf215; ..\..\..\..\..\..\..\..\sam\services\timer_1us; ..\..\..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_tx_rx; ..\..\..\..\..\..\..\..\sam\services\plc\busart_if; ..\..\..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\G3; ..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_fe; ..\..\..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\..\..\common\utils\stdio\stdio_udc; ..\..\..\..\..\..\..\..\sam\drivers\matrix; ..\..\..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_common; ..\..\..\..\..\..\..\..\sam\drivers\udp; ..\..\..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360; ..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_bbc; ..; ..\..\..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\..\..\sam\drivers\usart; ..\..\..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\addons; ..\..\..\..\..\..\..\..\sam\services\rf\prf_if\at86rf215; ..\..\..\..\coup_tx_config\pl360_wrp\g3_phy; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_phy_tester_hybrid_tool_flash.bin
  ILINK.IlinkOutputFile: apps_phy_tester_hybrid_tool_flash.out
  ILINK.IlinkIcfFile: ..\..\..\linker_scripts\iar\samg55_flash_isp.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\..\..\atpl\bin\ATPL360B_G3_CENA.bin,atpl_bin_cena,P_atpl_bin_cena,8; --image_input ..\..\..\..\..\..\..\..\atpl\bin\ATPL360B_G3_FCC.bin,atpl_bin_fcc,P_atpl_bin_fcc,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/components/rf/at86rf215
    ../../../../../../../../common/components/rf/at86rf215/: at86rf215.c ieee_15_4_sun_fsk.h at86rf.h ieee_15_4_sun_ofdm.h at86rf_defs.h at86rf_version.h
  group common/components/rf/at86rf215/rf215_bbc
    ../../../../../../../../common/components/rf/at86rf215/rf215_bbc/: rf215_bbc.c rf215_bbc.h rf215_bbc_defs.h
  group common/components/rf/at86rf215/rf215_common
    ../../../../../../../../common/components/rf/at86rf215/rf215_common/: rf215_trx_ctl.c rf215_spi.c rf215_spi.h rf215_phy_defs.h rf215_trx_ctl.h rf215_reg.h rf215_conf_check.h
  group common/components/rf/at86rf215/rf215_irq
    ../../../../../../../../common/components/rf/at86rf215/rf215_irq/: rf215_irq.c rf215_irq.h rf215_irq_defs.h
  group common/components/rf/at86rf215/rf215_tx_rx
    ../../../../../../../../common/components/rf/at86rf215/rf215_tx_rx/: rf215_rx.c rf215_tx.c rf215_tx_rx_defs.h rf215_tx_rx.h
  group common/components/rf/at86rf215/rf215_pll
    ../../../../../../../../common/components/rf/at86rf215/rf215_pll/: rf215_pll.c rf215_pll_defs.h rf215_pll.h
  group common/components/rf/at86rf215/rf215_fe
    ../../../../../../../../common/components/rf/at86rf215/rf215_fe/: rf215_fe.c rf215_fe.h rf215_fe_defs.h
  group common/components/rf/at86rf215/addons
    ../../../../../../../../common/components/rf/at86rf215/addons/: rf215_addon.h
  group common/components/rf/at86rf215/addons/serial_if
    ../../../../../../../../common/components/rf/at86rf215/addons/serial_if/: rf215_serial_if.c
  group common/components/plc/atpl360
    ../../../../../../../../common/components/plc/atpl360/: atpl360_boot.c atpl360.c atpl360_IB.c atpl360_hal_spi.c atpl360_IB.h atpl360_boot.h atpl360_hal_spi.h atpl360.h atpl360_IB_db_api.h atpl360_exception.h
  group common/components/plc/atpl360/addons
    ../../../../../../../../common/components/plc/atpl360/addons/: addon_api.h
  group common/components/plc/atpl360/addons/serial_if
    ../../../../../../../../common/components/plc/atpl360/addons/serial_if/: serial_if.c serial_if_g3.c serial_if.h
  group common/components/plc/atpl360/G3
    ../../../../../../../../common/components/plc/atpl360/G3/: atpl360_IB_db.c atpl360_comm.c general_defs.h atpl360_comm.h atpl360_IB_db.h
  group common/services/usb
    ../../../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc.h udi_cdc_conf.h
  group common/services/usb/udc
    ../../../../../../../../common/services/usb/udc/: udc.c udc_desc.h udc.h udi.h udd.h
  group common/services/sleepmgr
    ../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/samg
    ../../../../../../../../common/services/clock/samg/: sysclk.c osc.h sysclk.h pll.h genclk.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_udc
    ../../../../../../../../common/utils/stdio/stdio_udc/: stdio_udc.h
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group sam/services/plc/busart_if
    ../../../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/plc/buart_if
    ../../../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/pplc_if/atpl360
    ../../../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c pplc_if.h
  group sam/services/plc/pcrc
    ../../../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/usb_wrp
    ../../../../../../../../sam/services/plc/usb_wrp/: usb_wrp.c usb_wrp.h
  group sam/services/plc/usi
    ../../../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/timer_1us
    ../../../../../../../../sam/services/timer_1us/: timer_1us.c timer_1us_hal.h timer_1us.h
  group sam/services/timer_1us/hal_samg55
    ../../../../../../../../sam/services/timer_1us/hal_samg55/: timer_1us_hal.c
  group sam/services/rf/prf_if/at86rf215
    ../../../../../../../../sam/services/rf/prf_if/at86rf215/: prf_if.c prf_if.h
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/adc
    ../../../../../../../../sam/drivers/adc/: adc2.c adc2.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/matrix
    ../../../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/flexcom
    ../../../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/efc
    ../../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/supc
    ../../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/udp
    ../../../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/boards/pl360g55cf_ek
    ../../../../../../../../sam/boards/pl360g55cf_ek/: init.c pl360g55cf_ek.h led.h
  group sam/utils
    ../../../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../../../../sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../../../../sam/utils/cmsis/samg/samg55/include/: samg55j18.h samg55g18.h samg55g19.h samg55.h samg55n19.h system_samg55.h samg55j19.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../../../../sam/utils/cmsis/samg/samg55/include/instance/: cmcc.h crccu.h twi5.h pdmic1.h usart2.h usart0.h flexcom1.h udp.h usart7.h wdt.h twi7.h supc.h twi6.h usart3.h uhp.h i2sc0.h usart1.h piob.h spi5.h efc.h flexcom4.h tc0.h flexcom7.h mem2mem.h matrix.h rtt.h rstc.h spi1.h twi1.h pmc.h twi2.h spi3.h i2sc1.h chipid.h usart5.h flexcom3.h twi3.h flexcom0.h flexcom6.h tc1.h spi7.h spi6.h spi0.h twi0.h pioa.h pdmic0.h spi2.h adc.h rtc.h usart6.h usart4.h gpbr.h spi4.h flexcom2.h twi4.h flexcom5.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../../../../sam/utils/cmsis/samg/samg55/include/pio/: samg55g19.h samg55n19.h samg55j19.h samg55g18.h samg55j18.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../../../../sam/utils/cmsis/samg/samg55/include/component/: uhp.h rtc.h pmc.h pio.h supc.h matrix.h efc.h cmcc.h flexcom.h rstc.h i2sc.h twi.h crccu.h pdmic.h mem2mem.h pdc.h udp.h gpbr.h usart.h spi.h chipid.h rtt.h tc.h wdt.h adc.h
  group sam/utils/fpu
    ../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group thirdparty/g3/phy/atpl360/coup_tx_config
    ../../../../coup_tx_config/: coup_tx_config.c coup_tx_config.h coup_defs.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_params
    ../../../../coup_tx_config/coup_params/: plcoup007_cen_a.h plcoup006_fcc.h plcoup011_fcc.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_conf/pl360_cen_a_fcc
    ../../../../coup_tx_config/coup_conf/pl360_cen_a_fcc/: coup_conf.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/pl360_wrp/g3_phy
    ../../../../coup_tx_config/pl360_wrp/g3_phy/: coup_pl360_wrp.h
  group thirdparty/g3/phy/atpl360/apps/phy_tester_hybrid_tool
    ../../: phy_embedded_example.c
  group thirdparty/g3/phy/atpl360/apps/phy_tester_hybrid_tool/samg55j19_pl360g55cf_ek_hybrid
    ../: conf_at86rf.h conf_busart_if.h conf_timer_1us.h conf_project.h conf_clock.h conf_prf_if.h conf_buart_if.h conf_usb.h conf_usi.h conf_sleepmgr.h conf_pplc_if.h conf_board.h conf_atpl360.h conf_uart_serial.h
  group thirdparty/g3/phy/atpl360/apps/phy_tester_hybrid_tool/samg55j19_pl360g55cf_ek_hybrid/iar
    ./: asf.h
