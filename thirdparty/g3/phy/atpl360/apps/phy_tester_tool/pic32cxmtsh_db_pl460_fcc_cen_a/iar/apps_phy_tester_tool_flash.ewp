# IAR project apps_phy_tester_tool_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PIC32CX2051MTSH128_0 Microchip PIC32CX2051MTSH128 Core 0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD=PIC32CXMTSH_DB; ARM_MATH_CM4=true; __PIC32CX2051MTSH128_0__
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include; ..\..\..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\..\..\sam\services\plc\pcrc; ..\..\..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\..\..\sam\services\plc\usi; ..\..\..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\..\..\sam\drivers\slcdc; ..\..\..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\..\..\sam\boards\pic32cxmtsh_db; ..\..\..\..\coup_tx_config; ..\..\..\..\coup_tx_config\coup_params; ..\..\..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\..\..\sam\services\plc\buart_if; ..\..\..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\..\..\sam\drivers\supc\pic32cx; ..\..\..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\..\..\common\services\serial\pic32cx_uart; ..\..\..\..\..\..\..\..\sam\components\display\cl010; ..\..\..\..\..\..\..\..\sam\drivers\adc; ..\..; ..; ..\..\..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates; ..\..\..\..\..\..\..\..\sam\services\plc\busart_if; ..\..\..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\G3; ..\..\..\..\..\..\..\..\sam\drivers\pmc\pic32cx; ..\..\..\..\..\..\..\..\sam\drivers\pio\pic32cx; ..\..\..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\coup_tx_config\coup_conf\pl460_fcc_cen_a; ..\..\..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\addons\serial_if; ..\..\..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360; ..\..\..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\..\..\sam\drivers\usart; ..\..\..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\addons; ..\..\..\..\..\..\..\..\sam\drivers\rstc; ..\..\..\..\coup_tx_config\pl360_wrp\g3_phy; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_phy_tester_tool_flash.bin
  ILINK.IlinkOutputFile: apps_phy_tester_tool_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\..\sam\utils\linker_scripts\pic32cx\iar\pic32cx2051mtsh128_0_flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\..\..\atpl\bin\ATPL360B_G3_CENA.bin,atpl_bin_cena,P_atpl_bin_cena,8; --image_input ..\..\..\..\..\..\..\..\atpl\bin\ATPL360B_G3_FCC.bin,atpl_bin_fcc,P_atpl_bin_fcc,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  group common/services/sleepmgr
    ../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/pic32cx
    ../../../../../../../../common/services/clock/pic32cx/: sysclk.c pll.h sysclk.h genclk.h osc.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/pic32cx_uart
    ../../../../../../../../common/services/serial/pic32cx_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/pic32cx
    ../../../../../../../../common/services/ioport/pic32cx/: ioport_pio.h
  group common/components/plc/atpl360
    ../../../../../../../../common/components/plc/atpl360/: atpl360_boot.c atpl360.c atpl360_IB.c atpl360_hal_spi.c atpl360_boot.h atpl360_IB.h atpl360_IB_db_api.h atpl360_exception.h atpl360_hal_spi.h atpl360.h
  group common/components/plc/atpl360/addons
    ../../../../../../../../common/components/plc/atpl360/addons/: addon_api.h
  group common/components/plc/atpl360/addons/serial_if
    ../../../../../../../../common/components/plc/atpl360/addons/serial_if/: serial_if.c serial_if_g3.c serial_if.h
  group common/components/plc/atpl360/G3
    ../../../../../../../../common/components/plc/atpl360/G3/: atpl360_IB_db.c atpl360_comm.c general_defs.h atpl360_comm.h atpl360_IB_db.h
  group common/utils
    ../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group sam/services/plc/busart_if
    ../../../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/plc/buart_if
    ../../../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/pplc_if/atpl360
    ../../../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c pplc_if.h
  group sam/services/plc/pcrc
    ../../../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/usi
    ../../../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/drivers/pio/pic32cx
    ../../../../../../../../sam/drivers/pio/pic32cx/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/rstc
    ../../../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/slcdc
    ../../../../../../../../sam/drivers/slcdc/: slcdc.c slcdc.h
  group sam/drivers/efc
    ../../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc/pic32cx
    ../../../../../../../../sam/drivers/supc/pic32cx/: supc.c supc.h
  group sam/drivers/flexcom
    ../../../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/pmc/pic32cx
    ../../../../../../../../sam/drivers/pmc/pic32cx/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/adc
    ../../../../../../../../sam/drivers/adc/: adc.c adc.h
  group sam/utils
    ../../../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/pic32cx/source/templates
    ../../../../../../../../sam/utils/cmsis/pic32cx/source/templates/: system_pic32cx.c
  group sam/utils/cmsis/pic32cx/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/pic32cx/source/templates/iar/: startup_pic32cx.c
  group sam/utils/cmsis/pic32cx/include
    ../../../../../../../../sam/utils/cmsis/pic32cx/include/: pic32cx5112mtg64.h pic32cx5112mtsh100_1.h pic32cx1025mtc100_0.h pic32cx2051mtsh100_1.h pic32cx2051mtsh100_0.h pic32cx2051mtc100_0.h pic32cx1025mtg100.h pic32cx2051mtg100.h pic32cx2038mtsh100_1.h pic32cx5112mtc100_0.h pic32cx2051mtg64.h pic32cx.h system_pic32cx.h pic32cx1025mtsh128_0.h pic32cx1025mtc100_1.h pic32cx2051mtsh128_0.h pic32cx5112mtsh100_0.h pic32cx2038mtsh128_1.h pic32cx2051mtc100_1.h pic32cx5112mtg100.h pic32cx2038mtc100_1.h pic32cx1025mtsh128_1.h pic32cx2038mtg64.h pic32cx2038mtsh100_0.h pic32cx1025mtsh100_0.h pic32cx1025mtg64.h pic32cx2038mtg100.h pic32cx2051mtsh128_1.h pic32cx1025mtsh100_1.h pic32cx5112mtsh128_0.h pic32cx5112mtsh128_1.h pic32cx2038mtsh128_0.h pic32cx5112mtc100_1.h pic32cx2038mtc100_0.h
  group sam/utils/cmsis/pic32cx/include/instance
    ../../../../../../../../sam/utils/cmsis/pic32cx/include/instance/: twi0.h flexcom4.h flexcom3.h spi7.h ipc1.h cmcc0.h pmc.h twi1.h flexcom2.h dwdt.h usart6.h spi1.h usart7.h seafec.h adc.h flexcom0.h twi4.h rstc.h twi2.h flexcom6.h spi5.h spi4.h ipc0.h trng.h mcspi.h sha.h usart2.h sfr.h usart0.h sefc0.h mem2mem0.h sfrbu.h aes.h matrix0.h spi0.h icm.h matrix2.h tc0.h spi3.h tc2.h pio.h rtc.h slcdc.h cpkcc.h gpbr.h acc.h twi6.h usart3.h usart1.h sefc1.h qspi.h cmcc1.h flexcom5.h matrix1.h syscwp.h spi2.h matrix3.h i2smcc.h flexcom7.h twi7.h tc3.h usart5.h supc.h tc1.h twi5.h uart.h flexcom1.h rtt.h pwm.h usart4.h chipid.h aesb.h twi3.h spi6.h mem2mem1.h
  group sam/utils/cmsis/pic32cx/include/component
    ../../../../../../../../sam/utils/cmsis/pic32cx/include/component/: trng.h i2smcc.h rtt.h sfr.h gpbr.h spi.h supc.h tc.h acc.h ipc.h slcdc.h rstc.h qspi.h pmc.h mcspi.h uart.h dwdt.h aes.h icm.h adc.h cmcc.h pio.h emafelpfif.h pdc.h mem2mem.h sha.h sefc.h aesb.h usart.h rtc.h twi.h cpkcc.h chipid.h pwm.h flexcom.h syscwp.h matrix.h sfrbu.h
  group sam/utils/cmsis/pic32cx/include/pio
    ../../../../../../../../sam/utils/cmsis/pic32cx/include/pio/: pic32cx1025mtg64.h pic32cx2038mtg100.h pic32cx5112mtc100.h pic32cx2038mtc100.h pic32cx2051mtsh128.h pic32cx2051mtg64.h pic32cx1025mtsh100.h pic32cx1025mtsh128.h pic32cx2051mtc100.h pic32cx2038mtsh128.h pic32cx2038mtg64.h pic32cx2051mtg100.h pic32cx2038mtsh100.h pic32cx1025mtg100.h pic32cx5112mtg100.h pic32cx5112mtsh100.h pic32cx5112mtg64.h pic32cx2051mtsh100.h pic32cx1025mtc100.h pic32cx5112mtsh128.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group sam/utils/fpu
    ../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/components/display/cl010
    ../../../../../../../../sam/components/display/cl010/: cl010_slcdc.c cl010_font.h cl010_segmap.h cl010.h
  group sam/boards/pic32cxmtsh_db
    ../../../../../../../../sam/boards/pic32cxmtsh_db/: init.c pic32cxmtsh_db.h led.h
  group thirdparty/g3/phy/atpl360/apps/phy_tester_tool
    ../../: phy_embedded_example.c
  group thirdparty/g3/phy/atpl360/apps/phy_tester_tool/pic32cxmtsh_db_pl460_fcc_cen_a
    ../: conf_cl010_slcdc.h conf_clock.h conf_project.h conf_buart_if.h conf_slcdc.h conf_usi.h conf_sleepmgr.h conf_pplc_if.h conf_board.h conf_busart_if.h conf_atpl360.h conf_uart_serial.h
  group thirdparty/g3/phy/atpl360/apps/phy_tester_tool/pic32cxmtsh_db_pl460_fcc_cen_a/iar
    ./: asf.h
  group thirdparty/g3/phy/atpl360/coup_tx_config
    ../../../../coup_tx_config/: coup_tx_config.c coup_tx_config.h coup_defs.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_params
    ../../../../coup_tx_config/coup_params/: pl460_sb_fcc.h pl460_1_5b_fcc.h pl460_plcoup007_cen_a.h plcoup007_cen_a.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/pl360_wrp/g3_phy
    ../../../../coup_tx_config/pl360_wrp/g3_phy/: coup_pl360_wrp.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_conf/pl460_fcc_cen_a
    ../../../../coup_tx_config/coup_conf/pl460_fcc_cen_a/: coup_conf.h
