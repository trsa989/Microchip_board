# Keil uVision project apps_phy_tester_tool_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAM4CMS16C:CM4_P0 Atmel
  pack: Keil.SAM4_DFP.1.6.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x01000000,0x100000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: apps_template_app
  c flags: Optim=3 oTime=1 uC99=1 wLevel=2
  c define: BOARD=ATPL360MB __SAM4CMS16C_0__ ARM_MATH_CM4=true
  c misc: --diag_suppress=66
  c include: ..\..\..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\..\..\..\..\sam\services\plc\pcrc;..\..\..\..\..\..\..\..\sam\services\plc\buart_if;..\..\..\..\..\..\..\..\common\services\ioport;..\..\..\..\..\..\..\..\sam\components\display\c0216CiZ;..\..\..\..\..\..\..\..\sam\utils;..\..\..\..\coup_tx_config;..\..\..\..\coup_tx_config\coup_params;..\..\..\..\..\..\..\..\common\components\plc\atpl360;..\..\..\..\..\..\..\..\sam\drivers\pdc;..\..\..\..\..\..\..\..\common\services\twi;..\..\..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\..\..\..\..\sam\drivers\uart;..\..\..\..\..\..\..\..\sam\drivers\pmc;..\..\..\..\..\..\..\..\sam\boards\atpl360mb;..\..\..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\..\..\common\utils;..\..\..\..\..\..\..\..\common\services\delay;..\..\..\..\..\..\..\..\sam\drivers\pio;..\..\..\..\..\..\..\..\sam\drivers\twi;..;..\..\..\..\..\..\..\..\sam\drivers\adc;..\..\..\..\..\..\..\..\sam\boards;..\..\..\..\..\..\..\..\sam\drivers\supc;..\..;..\..\..\..\..\..\..\..\sam\services\plc\busart_if;..\..\..\..\..\..\..\..\common\services\clock;..\..\..\..\..\..\..\..\common\components\plc\atpl360\G3;..\..\..\..\..\..\..\..\sam\utils\cmsis\sam4cm\source\templates;..\..\..\..\..\..\..\..\sam\services\plc\usi;..\..\..\..\coup_tx_config\coup_conf\pl360_cen_b;..\..\..\..\..\..\..\..\common\services\gpio;..\..\..\..\..\..\..\..\sam\utils\header_files;..\..\..\..\..\..\..\..\common\services\serial\sam_uart;..\..\..\..\..\..\..\..\common\components\plc\atpl360\addons\serial_if;..\..\..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\..\..\sam\utils\cmsis\sam4cm\include;..\..\..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360;..\..\..\..\..\..\..\..\common\boards;..\..\..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\..\..\..\common\components\plc\atpl360\addons;..\..\..\..\..\..\..\..\sam\drivers\usart;..\..\..\..\coup_tx_config\pl360_wrp\g3_phy;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x1000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\sam4c16c.sct
  group Startup
    ./: startup_SAM4CM.s retarget.c system_sam4cm.c atpl_bin.S
  group sam_services_plc_busart_if
    ../../../../../../../../sam/services/plc/busart_if/: busart_if.c
  group sam_services_plc_buart_if
    ../../../../../../../../sam/services/plc/buart_if/: buart_if.c
  group sam_services_plc_pplc_if_atpl360
    ../../../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c
  group sam_services_plc_pcrc
    ../../../../../../../../sam/services/plc/pcrc/: pcrc.c
  group sam_services_plc_usi
    ../../../../../../../../sam/services/plc/usi/: usi.c
  group sam_drivers_usart
    ../../../../../../../../sam/drivers/usart/: usart.c
  group sam_drivers_pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c
  group sam_drivers_tc
    ../../../../../../../../sam/drivers/tc/: tc.c
  group sam_drivers_pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam_drivers_spi
    ../../../../../../../../sam/drivers/spi/: spi.c
  group sam_drivers_supc
    ../../../../../../../../sam/drivers/supc/: supc.c
  group sam_drivers_pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam_drivers_uart
    ../../../../../../../../sam/drivers/uart/: uart.c
  group sam_drivers_twi
    ../../../../../../../../sam/drivers/twi/: twi.c
  group sam_drivers_adc
    ../../../../../../../../sam/drivers/adc/: adc.c adc_sam3u.c
  group sam_boards_atpl360mb
    ../../../../../../../../sam/boards/atpl360mb/: init.c
  group sam_components_display_c0216CiZ
    ../../../../../../../../sam/components/display/c0216CiZ/: c0216CiZ.c
  group common_components_plc_atpl360_addons_serial_if
    ../../../../../../../../common/components/plc/atpl360/addons/serial_if/: serial_if.c serial_if_g3.c
  group common_components_plc_atpl360
    ../../../../../../../../common/components/plc/atpl360/: atpl360_boot.c atpl360.c
    ../../../../../../../../common/components/plc/atpl360/G3/: atpl360_IB_db.c atpl360_comm.c
  group common_components_plc_atpl360
    ../../../../../../../../common/components/plc/atpl360/: atpl360_IB.c atpl360_hal_spi.c
  group common_utils_stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common_utils_interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common_services_clock_sam4cm
    ../../../../../../../../common/services/clock/sam4cm/: sysclk.c
  group common_services_serial
    ../../../../../../../../common/services/serial/: usart_serial.c
  group common_services_delay_sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c
  group thirdparty_g3_phy_atpl360_apps_phy_tester_tool
    ../../: phy_embedded_example.c
  group thirdparty_g3_phy_atpl360_coup_tx_config
    ../../../../coup_tx_config/: coup_tx_config.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
