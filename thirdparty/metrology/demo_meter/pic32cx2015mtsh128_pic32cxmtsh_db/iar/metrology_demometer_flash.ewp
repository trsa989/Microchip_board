# IAR project metrology_demometer_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PIC32CX2051MTSH128_0 Microchip PIC32CX2051MTSH128 Core 0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD=PIC32CXMTSH_DB; ARM_MATH_CM4=true; __PIC32CX2051MTSH128_0__
  ICCARM.CCIncludePath2: ..\..\..\..\..\sam\utils\cmsis\pic32cx\include; ..\..\..\demo_app\history; ..\..\..\demo_app\presskey; ..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\sam\drivers\rtc; ..\..\..\..\..\common\services\ioport; ..\..\..\..\..\sam\drivers\slcdc; ..\..\..\..\..\sam\utils; ..\..\..\..\..\sam\boards\pic32cxmtsh_db; ..\..\..\..\..\sam\drivers\rtt; ..\..\..\..\..\common\boards; ..\..\..\..\..\sam\drivers\qspi\pic32cx; ..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\sam\boards; ..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates; ..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\sam\drivers\chipid; ..\..\..\..\..\sam\drivers\icm; ..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\sam\drivers\supc\pic32cx; ..\..\..\demo_app\metrology; ..\..\..\demo_app\energy; ..\..\..\demo_app\tou; ..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\common\utils; ..\..\..\demo_app\event; ..\..\..\..\..\sam\drivers\usart; ..\..\..\..\..\sam\drivers\cmcc; ..\..\..\..\..\common\services\serial\pic32cx_uart; ..\..\..\..\..\common\components\memory\qspi_flash\sst26vfxxx; ..\..\..\..\..\common\services\delay; ..\..\..\..\..\sam\components\display\cl010; ..\..\..\demo_app\rtcproc; ..\..\..\demo_app; ..\..\..\demo_app\command; ..\..\..\demo_app\display; ..\..\..\..\..\common\services\clock; ..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\..\sam\drivers\pmc\pic32cx; ..\..\..\..\..\sam\drivers\ipc; ..\..; ..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\sam\drivers\pio\pic32cx; ..; ..\..\..\..\..\sam\utils\header_files; ..\..\..\demo_app\demand; ..\..\..\demo_app\coproc; ..\..\..\..\..\common\services\serial; ..\..\..\..\..\sam\drivers\matrix\pic32cx; ..\..\..\demo_app\utils; ..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\sam\drivers\rstc; ..\..\..\demo_app\kenerl; ..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\sam\drivers\dwdt; ..\..\..\demo_app\basetimer; ..\..\..\demo_app\extmem; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: metrology_demometer_flash.bin
  ILINK.IlinkOutputFile: metrology_demometer_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\sam\utils\linker_scripts\pic32cx\iar\pic32cx2051mtsh128_0_flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\metrology_lib\core1_metlib.bin,core1_metlib,P_core1_metlib,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  group sam/drivers/supc/pic32cx
    ../../../../../sam/drivers/supc/pic32cx/: supc.c supc.h
  group sam/drivers/flexcom
    ../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/cmcc
    ../../../../../sam/drivers/cmcc/: cmcc.c cmcc.h
  group sam/drivers/chipid
    ../../../../../sam/drivers/chipid/: chipid.c chipid.h
  group sam/drivers/rtt
    ../../../../../sam/drivers/rtt/: rtt.c rtt.h
  group sam/drivers/rtc
    ../../../../../sam/drivers/rtc/: rtc.c rtc.h
  group sam/drivers/slcdc
    ../../../../../sam/drivers/slcdc/: slcdc.c slcdc.h
  group sam/drivers/pmc/pic32cx
    ../../../../../sam/drivers/pmc/pic32cx/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/dwdt
    ../../../../../sam/drivers/dwdt/: dwdt.c dwdt.h
  group sam/drivers/pio/pic32cx
    ../../../../../sam/drivers/pio/pic32cx/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/icm
    ../../../../../sam/drivers/icm/: icm.c icm.h
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pdc
    ../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/qspi/pic32cx
    ../../../../../sam/drivers/qspi/pic32cx/: qspi.c qspi.h
  group sam/drivers/gpbr
    ../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/rstc
    ../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/ipc
    ../../../../../sam/drivers/ipc/: ipc.c ipc.h
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/efc
    ../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/matrix/pic32cx
    ../../../../../sam/drivers/matrix/pic32cx/: matrix.c matrix.h
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/pic32cx/source/templates
    ../../../../../sam/utils/cmsis/pic32cx/source/templates/: system_pic32cx.c
  group sam/utils/cmsis/pic32cx/source/templates/iar
    ../../../../../sam/utils/cmsis/pic32cx/source/templates/iar/: startup_pic32cx.c
  group sam/utils/cmsis/pic32cx/include
    ../../../../../sam/utils/cmsis/pic32cx/include/: pic32cx2051mtsh128_0.h pic32cx1025mtg64.h pic32cx2051mtc100_0.h pic32cx2038mtsh128_1.h pic32cx5112mtsh128_0.h pic32cx2051mtsh128_1.h pic32cx1025mtsh128_0.h pic32cx2051mtc100_1.h pic32cx2038mtsh128_0.h pic32cx5112mtsh100_1.h pic32cx2051mtg100.h pic32cx5112mtg64.h pic32cx1025mtsh128_1.h pic32cx2051mtg64.h pic32cx2038mtsh100_1.h pic32cx2051mtsh100_1.h pic32cx2051mtsh100_0.h pic32cx2038mtc100_1.h pic32cx5112mtsh100_0.h pic32cx1025mtsh100_1.h pic32cx1025mtg100.h pic32cx1025mtsh100_0.h pic32cx5112mtc100_1.h pic32cx2038mtg64.h pic32cx2038mtsh100_0.h pic32cx2038mtc100_0.h pic32cx1025mtc100_0.h pic32cx5112mtsh128_1.h pic32cx1025mtc100_1.h pic32cx2038mtg100.h pic32cx.h pic32cx5112mtg100.h system_pic32cx.h pic32cx5112mtc100_0.h
  group sam/utils/cmsis/pic32cx/include/instance
    ../../../../../sam/utils/cmsis/pic32cx/include/instance/: ipc1.h aesb.h sefc0.h pio.h i2smcc.h pmc.h aes.h spi1.h trng.h usart3.h twi1.h flexcom4.h matrix0.h usart2.h cmcc0.h dwdt.h rstc.h acc.h twi5.h ipc0.h sefc1.h chipid.h twi6.h spi0.h twi0.h twi7.h matrix3.h adc.h spi3.h rtc.h mem2mem1.h tc0.h seafec.h twi4.h qspi.h usart4.h uart.h flexcom3.h twi2.h pwm.h sfrbu.h mcspi.h rtt.h matrix1.h gpbr.h spi5.h tc2.h supc.h flexcom1.h sha.h spi2.h tc1.h mem2mem0.h spi7.h usart0.h twi3.h usart6.h cpkcc.h flexcom5.h flexcom6.h icm.h spi4.h tc3.h flexcom2.h sfr.h flexcom7.h spi6.h syscwp.h flexcom0.h cmcc1.h usart1.h slcdc.h usart7.h matrix2.h usart5.h
  group sam/utils/cmsis/pic32cx/include/component
    ../../../../../sam/utils/cmsis/pic32cx/include/component/: adc.h rtc.h gpbr.h matrix.h mem2mem.h slcdc.h acc.h aesb.h sfr.h cmcc.h mcspi.h pmc.h icm.h rtt.h spi.h sefc.h flexcom.h chipid.h supc.h syscwp.h pdc.h cpkcc.h sfrbu.h qspi.h aes.h twi.h ipc.h usart.h pio.h sha.h emafelpfif.h dwdt.h pwm.h i2smcc.h rstc.h trng.h uart.h tc.h
  group sam/utils/cmsis/pic32cx/include/pio
    ../../../../../sam/utils/cmsis/pic32cx/include/pio/: pic32cx5112mtsh128.h pic32cx2038mtsh100.h pic32cx2038mtc100.h pic32cx5112mtg100.h pic32cx2051mtc100.h pic32cx2051mtsh100.h pic32cx2051mtg64.h pic32cx2038mtg64.h pic32cx1025mtg100.h pic32cx1025mtg64.h pic32cx1025mtsh100.h pic32cx5112mtc100.h pic32cx5112mtsh100.h pic32cx1025mtc100.h pic32cx1025mtsh128.h pic32cx2038mtsh128.h pic32cx2038mtg100.h pic32cx2051mtg100.h pic32cx5112mtg64.h pic32cx2051mtsh128.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../sam/utils/fpu/: fpu.h
  group sam/components/display/cl010
    ../../../../../sam/components/display/cl010/: cl010_slcdc.c cl010_font.h cl010_segmap.h cl010.h
  group sam/boards/pic32cxmtsh_db
    ../../../../../sam/boards/pic32cxmtsh_db/: init.c pic32cxmtsh_db.h led.h
  group thirdparty/metrology/demo_meter
    ../../: main.c main.h
  group thirdparty/metrology/demo_meter/pic32cx2015mtsh128_pic32cxmtsh_db
    ../: conf_cl010_slcdc.h conf_slcdc.h conf_sleepmgr.h conf_uart_serial.h conf_board.h conf_clock.h conf_command_serial.h conf_demo_app.h
  group thirdparty/metrology/demo_meter/pic32cx2015mtsh128_pic32cxmtsh_db/iar
    ./: asf.h
  group thirdparty/metrology/demo_app
    ../../../demo_app/: demo_app_version.h
  group thirdparty/metrology/demo_app/kenerl
    ../../../demo_app/kenerl/: task.c task.h
  group thirdparty/metrology/demo_app/tou
    ../../../demo_app/tou/: tou.c tou.h
  group thirdparty/metrology/demo_app/rtcproc
    ../../../demo_app/rtcproc/: rtcproc.c rtcproc.h
  group thirdparty/metrology/demo_app/utils
    ../../../demo_app/utils/: utils.c utils.h
  group thirdparty/metrology/demo_app/basetimer
    ../../../demo_app/basetimer/: basetime.c basetime.h
  group thirdparty/metrology/demo_app/energy
    ../../../demo_app/energy/: energy.c energy.h
  group thirdparty/metrology/demo_app/metrology
    ../../../demo_app/metrology/: metrology.c metrology.h
  group thirdparty/metrology/demo_app/extmem
    ../../../demo_app/extmem/: extmem.c extmem.h
  group thirdparty/metrology/demo_app/coproc
    ../../../demo_app/coproc/: coproc.c coproc.h
  group thirdparty/metrology/demo_app/command
    ../../../demo_app/command/: command.c command.h
  group thirdparty/metrology/demo_app/demand
    ../../../demo_app/demand/: demand.c demand.h
  group thirdparty/metrology/demo_app/event
    ../../../demo_app/event/: event.c event.h
  group thirdparty/metrology/demo_app/history
    ../../../demo_app/history/: history.c history.h
  group thirdparty/metrology/demo_app/display
    ../../../demo_app/display/: display.c display.h
  group thirdparty/metrology/demo_app/presskey
    ../../../demo_app/presskey/: presskey.c presskey.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h pll.h genclk.h
  group common/services/clock/pic32cx
    ../../../../../common/services/clock/pic32cx/: sysclk.c genclk.h osc.h sysclk.h pll.h
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/pic32cx_uart
    ../../../../../common/services/serial/pic32cx_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/pic32cx
    ../../../../../common/services/ioport/pic32cx/: ioport_pio.h
  group common/components/memory/qspi_flash/sst26vfxxx
    ../../../../../common/components/memory/qspi_flash/sst26vfxxx/: sst26vfxxx.c sst26vfxxx.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
