# Keil uVision project SERIAL_BOOTLOADER.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::..\..\Keil_FS\ARM\ARMCC)
  device: ATSAMG55J19 Microchip
  pack: Microchip.SAMG_DFP.3.8.197
  cpu: IRAM(0x20000000,0x00028000) IROM(0x00400000,0x00080000) IROM2(0x00800000,0x00400000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SERIAL_BOOTLOADER +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=1
  c define: __SAMG55J19__ UDD_ENABLE BOARD=PL360G55CF_EK ARM_MATH_CM4=true __CC_ARM
  c include: .\src;..\..\samg55j19_pl360g55cx_ek;..\..\..\serial_bootloader;..\..\..\..\utils;..\..\..\..\..\common\utils;..\..\..\..\utils\preprocessor;..\..\..\..\utils\header_files;..\..\..\..\utils\cmsis\samg\samg55\include;..\..\..\..\..\thirdparty\CMSIS\Include;..\..\..\..\..\common\services\delay;..\..\..\..\..\common\services\clock;..\..\..\..\..\common\boards;..\..\..\..\drivers\pmc;..\..\..\..\drivers\efc;..\..\..\..\boards;..\..\..\..\drivers\flexcom;..\..\..\..\services\flash_efc;..\..\..\..\..\common\services\gpio;..\..\..\..\drivers\pio;..\..\..\..\..\common\services\ioport;..\..\..\..\drivers\matrix;..\..\..\..\boards\pl360g55cf_ek;..\..\..\..\utils\fpu;..\..\..\..\drivers\supc;..\..\..\..\..\common\services\sleepmgr;..\..\..\..\drivers\usart;..\..\..\..\..\common\services\usb\class\cdc;..\..\..\..\..\common\services\usb\class\cdc\device;..\..\..\..\..\common\services\usb;..\..\..\..\..\common\services\usb\udc;..\..\..\..\drivers\tc;..\..\..\..\..\thirdparty\g3\apps\adp_mac_serialized_app\samg55j19_pl360g55cf_ek_hybrid;..\..\..\..\drivers\pdc;..\..\..\..\drivers\gpbr;.\startup
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x80000
  memory RVCT5: ROM 0x800000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\Objects\SERIAL_BOOTLOADER.sct
  link misc: --map
  group Source Group 1
    ../../: main.c serial_monitor.c usart_serial.c
    ./startup/: startup_samg55j19.s
  group sam
    ../../../../services/flash_efc/: flash_efc.c
    ../../../../boards/pl360g55cf_ek/: init.c
    ../../../../drivers/pmc/: pmc.c sleep.c
    ../../../../../common/services/clock/samg/: sysclk.c
    ../../../../../common/services/usb/udc/: udc.c
    ../../../../../common/services/delay/sam/: cycle_counter.c
    ../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
    ../../../../drivers/flexcom/: flexcom.c
    ../../../../services/plc/busart_if/: busart_if.c
    ../../../../drivers/usart/: usart.c
    ../../../../drivers/efc/: efc.c
    ../../../../drivers/pio/: pio.c
    ../../../../utils/cmsis/samg/samg55/source/templates/: system_samg55.c
    ../../../../drivers/supc/: supc.c
    ../../../../drivers/udp/: udp_device.c
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
    ../../../../../common/services/sleepmgr/sam/: sleepmgr.c
    ../../../../drivers/pdc/: pdc.c
    ../../../../drivers/tc/: tc.c
    ../../../../drivers/matrix/: matrix.c
    ../../../../drivers/gpbr/: gpbr.c
software components: CMSIS-Compiler:I/O:STDOUT 1.0.0, CMSIS:CORE 5.6.0
